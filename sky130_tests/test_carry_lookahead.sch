** sch_path: sky130_tests/test_carry_lookahead.sch
* Copyright 2021 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
**.subckt test_carry_lookahead
*+ A[255],A[254],A[253],A[252],A[251],A[250],A[249],A[248],A[247],A[246],A[245],A[244],A[243],A[242],A[241],A[240],A[239],A[238],A[237],A[236],A[235],A[234],A[233],A[232],A[231],A[230],A[229],A[228],A[227],A[226],A[225],A[224],A[223],A[222],A[221],A[220],A[219],A[218],A[217],A[216],A[215],A[214],A[213],A[212],A[211],A[210],A[209],A[208],A[207],A[206],A[205],A[204],A[203],A[202],A[201],A[200],A[199],A[198],A[197],A[196],A[195],A[194],A[193],A[192],A[191],A[190],A[189],A[188],A[187],A[186],A[185],A[184],A[183],A[182],A[181],A[180],A[179],A[178],A[177],A[176],A[175],A[174],A[173],A[172],A[171],A[170],A[169],A[168],A[167],A[166],A[165],A[164],A[163],A[162],A[161],A[160],A[159],A[158],A[157],A[156],A[155],A[154],A[153],A[152],A[151],A[150],A[149],A[148],A[147],A[146],A[145],A[144],A[143],A[142],A[141],A[140],A[139],A[138],A[137],A[136],A[135],A[134],A[133],A[132],A[131],A[130],A[129],A[128],A[127],A[126],A[125],A[124],A[123],A[122],A[121],A[120],A[119],A[118],A[117],A[116],A[115],A[114],A[113],A[112],A[111],A[110],A[109],A[108],A[107],A[106],A[105],A[104],A[103],A[102],A[101],A[100],A[99],A[98],A[97],A[96],A[95],A[94],A[93],A[92],A[91],A[90],A[89],A[88],A[87],A[86],A[85],A[84],A[83],A[82],A[81],A[80],A[79],A[78],A[77],A[76],A[75],A[74],A[73],A[72],A[71],A[70],A[69],A[68],A[67],A[66],A[65],A[64],A[63],A[62],A[61],A[60],A[59],A[58],A[57],A[56],A[55],A[54],A[53],A[52],A[51],A[50],A[49],A[48],A[47],A[46],A[45],A[44],A[43],A[42],A[41],A[40],A[39],A[38],A[37],A[36],A[35],A[34],A[33],A[32],A[31],A[30],A[29],A[28],A[27],A[26],A[25],A[24],A[23],A[22],A[21],A[20],A[19],A[18],A[17],A[16],A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*+ B[255],B[254],B[253],B[252],B[251],B[250],B[249],B[248],B[247],B[246],B[245],B[244],B[243],B[242],B[241],B[240],B[239],B[238],B[237],B[236],B[235],B[234],B[233],B[232],B[231],B[230],B[229],B[228],B[227],B[226],B[225],B[224],B[223],B[222],B[221],B[220],B[219],B[218],B[217],B[216],B[215],B[214],B[213],B[212],B[211],B[210],B[209],B[208],B[207],B[206],B[205],B[204],B[203],B[202],B[201],B[200],B[199],B[198],B[197],B[196],B[195],B[194],B[193],B[192],B[191],B[190],B[189],B[188],B[187],B[186],B[185],B[184],B[183],B[182],B[181],B[180],B[179],B[178],B[177],B[176],B[175],B[174],B[173],B[172],B[171],B[170],B[169],B[168],B[167],B[166],B[165],B[164],B[163],B[162],B[161],B[160],B[159],B[158],B[157],B[156],B[155],B[154],B[153],B[152],B[151],B[150],B[149],B[148],B[147],B[146],B[145],B[144],B[143],B[142],B[141],B[140],B[139],B[138],B[137],B[136],B[135],B[134],B[133],B[132],B[131],B[130],B[129],B[128],B[127],B[126],B[125],B[124],B[123],B[122],B[121],B[120],B[119],B[118],B[117],B[116],B[115],B[114],B[113],B[112],B[111],B[110],B[109],B[108],B[107],B[106],B[105],B[104],B[103],B[102],B[101],B[100],B[99],B[98],B[97],B[96],B[95],B[94],B[93],B[92],B[91],B[90],B[89],B[88],B[87],B[86],B[85],B[84],B[83],B[82],B[81],B[80],B[79],B[78],B[77],B[76],B[75],B[74],B[73],B[72],B[71],B[70],B[69],B[68],B[67],B[66],B[65],B[64],B[63],B[62],B[61],B[60],B[59],B[58],B[57],B[56],B[55],B[54],B[53],B[52],B[51],B[50],B[49],B[48],B[47],B[46],B[45],B[44],B[43],B[42],B[41],B[40],B[39],B[38],B[37],B[36],B[35],B[34],B[33],B[32],B[31],B[30],B[29],B[28],B[27],B[26],B[25],B[24],B[23],B[22],B[21],B[20],B[19],B[18],B[17],B[16],B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0] CIN
*.ipin
*+ A[255],A[254],A[253],A[252],A[251],A[250],A[249],A[248],A[247],A[246],A[245],A[244],A[243],A[242],A[241],A[240],A[239],A[238],A[237],A[236],A[235],A[234],A[233],A[232],A[231],A[230],A[229],A[228],A[227],A[226],A[225],A[224],A[223],A[222],A[221],A[220],A[219],A[218],A[217],A[216],A[215],A[214],A[213],A[212],A[211],A[210],A[209],A[208],A[207],A[206],A[205],A[204],A[203],A[202],A[201],A[200],A[199],A[198],A[197],A[196],A[195],A[194],A[193],A[192],A[191],A[190],A[189],A[188],A[187],A[186],A[185],A[184],A[183],A[182],A[181],A[180],A[179],A[178],A[177],A[176],A[175],A[174],A[173],A[172],A[171],A[170],A[169],A[168],A[167],A[166],A[165],A[164],A[163],A[162],A[161],A[160],A[159],A[158],A[157],A[156],A[155],A[154],A[153],A[152],A[151],A[150],A[149],A[148],A[147],A[146],A[145],A[144],A[143],A[142],A[141],A[140],A[139],A[138],A[137],A[136],A[135],A[134],A[133],A[132],A[131],A[130],A[129],A[128],A[127],A[126],A[125],A[124],A[123],A[122],A[121],A[120],A[119],A[118],A[117],A[116],A[115],A[114],A[113],A[112],A[111],A[110],A[109],A[108],A[107],A[106],A[105],A[104],A[103],A[102],A[101],A[100],A[99],A[98],A[97],A[96],A[95],A[94],A[93],A[92],A[91],A[90],A[89],A[88],A[87],A[86],A[85],A[84],A[83],A[82],A[81],A[80],A[79],A[78],A[77],A[76],A[75],A[74],A[73],A[72],A[71],A[70],A[69],A[68],A[67],A[66],A[65],A[64],A[63],A[62],A[61],A[60],A[59],A[58],A[57],A[56],A[55],A[54],A[53],A[52],A[51],A[50],A[49],A[48],A[47],A[46],A[45],A[44],A[43],A[42],A[41],A[40],A[39],A[38],A[37],A[36],A[35],A[34],A[33],A[32],A[31],A[30],A[29],A[28],A[27],A[26],A[25],A[24],A[23],A[22],A[21],A[20],A[19],A[18],A[17],A[16],A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*.ipin
*+ B[255],B[254],B[253],B[252],B[251],B[250],B[249],B[248],B[247],B[246],B[245],B[244],B[243],B[242],B[241],B[240],B[239],B[238],B[237],B[236],B[235],B[234],B[233],B[232],B[231],B[230],B[229],B[228],B[227],B[226],B[225],B[224],B[223],B[222],B[221],B[220],B[219],B[218],B[217],B[216],B[215],B[214],B[213],B[212],B[211],B[210],B[209],B[208],B[207],B[206],B[205],B[204],B[203],B[202],B[201],B[200],B[199],B[198],B[197],B[196],B[195],B[194],B[193],B[192],B[191],B[190],B[189],B[188],B[187],B[186],B[185],B[184],B[183],B[182],B[181],B[180],B[179],B[178],B[177],B[176],B[175],B[174],B[173],B[172],B[171],B[170],B[169],B[168],B[167],B[166],B[165],B[164],B[163],B[162],B[161],B[160],B[159],B[158],B[157],B[156],B[155],B[154],B[153],B[152],B[151],B[150],B[149],B[148],B[147],B[146],B[145],B[144],B[143],B[142],B[141],B[140],B[139],B[138],B[137],B[136],B[135],B[134],B[133],B[132],B[131],B[130],B[129],B[128],B[127],B[126],B[125],B[124],B[123],B[122],B[121],B[120],B[119],B[118],B[117],B[116],B[115],B[114],B[113],B[112],B[111],B[110],B[109],B[108],B[107],B[106],B[105],B[104],B[103],B[102],B[101],B[100],B[99],B[98],B[97],B[96],B[95],B[94],B[93],B[92],B[91],B[90],B[89],B[88],B[87],B[86],B[85],B[84],B[83],B[82],B[81],B[80],B[79],B[78],B[77],B[76],B[75],B[74],B[73],B[72],B[71],B[70],B[69],B[68],B[67],B[66],B[65],B[64],B[63],B[62],B[61],B[60],B[59],B[58],B[57],B[56],B[55],B[54],B[53],B[52],B[51],B[50],B[49],B[48],B[47],B[46],B[45],B[44],B[43],B[42],B[41],B[40],B[39],B[38],B[37],B[36],B[35],B[34],B[33],B[32],B[31],B[30],B[29],B[28],B[27],B[26],B[25],B[24],B[23],B[22],B[21],B[20],B[19],B[18],B[17],B[16],B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.ipin CIN
x3[255] A[255] B[255] CARRY0[254] VSS VSS VCC VCC CARRY0[255] S0[255] sky130_fd_sc_hd__fah_1
x3[254] A[254] B[254] CARRY0[253] VSS VSS VCC VCC CARRY0[254] S0[254] sky130_fd_sc_hd__fah_1
x3[253] A[253] B[253] CARRY0[252] VSS VSS VCC VCC CARRY0[253] S0[253] sky130_fd_sc_hd__fah_1
x3[252] A[252] B[252] CARRY0[251] VSS VSS VCC VCC CARRY0[252] S0[252] sky130_fd_sc_hd__fah_1
x3[251] A[251] B[251] CARRY0[250] VSS VSS VCC VCC CARRY0[251] S0[251] sky130_fd_sc_hd__fah_1
x3[250] A[250] B[250] CARRY0[249] VSS VSS VCC VCC CARRY0[250] S0[250] sky130_fd_sc_hd__fah_1
x3[249] A[249] B[249] CARRY0[248] VSS VSS VCC VCC CARRY0[249] S0[249] sky130_fd_sc_hd__fah_1
x3[248] A[248] B[248] CARRY0[247] VSS VSS VCC VCC CARRY0[248] S0[248] sky130_fd_sc_hd__fah_1
x3[247] A[247] B[247] CARRY0[246] VSS VSS VCC VCC CARRY0[247] S0[247] sky130_fd_sc_hd__fah_1
x3[246] A[246] B[246] CARRY0[245] VSS VSS VCC VCC CARRY0[246] S0[246] sky130_fd_sc_hd__fah_1
x3[245] A[245] B[245] CARRY0[244] VSS VSS VCC VCC CARRY0[245] S0[245] sky130_fd_sc_hd__fah_1
x3[244] A[244] B[244] CARRY0[243] VSS VSS VCC VCC CARRY0[244] S0[244] sky130_fd_sc_hd__fah_1
x3[243] A[243] B[243] CARRY0[242] VSS VSS VCC VCC CARRY0[243] S0[243] sky130_fd_sc_hd__fah_1
x3[242] A[242] B[242] CARRY0[241] VSS VSS VCC VCC CARRY0[242] S0[242] sky130_fd_sc_hd__fah_1
x3[241] A[241] B[241] CARRY0[240] VSS VSS VCC VCC CARRY0[241] S0[241] sky130_fd_sc_hd__fah_1
x3[240] A[240] B[240] CARRY0[239] VSS VSS VCC VCC CARRY0[240] S0[240] sky130_fd_sc_hd__fah_1
x3[239] A[239] B[239] CARRY0[238] VSS VSS VCC VCC CARRY0[239] S0[239] sky130_fd_sc_hd__fah_1
x3[238] A[238] B[238] CARRY0[237] VSS VSS VCC VCC CARRY0[238] S0[238] sky130_fd_sc_hd__fah_1
x3[237] A[237] B[237] CARRY0[236] VSS VSS VCC VCC CARRY0[237] S0[237] sky130_fd_sc_hd__fah_1
x3[236] A[236] B[236] CARRY0[235] VSS VSS VCC VCC CARRY0[236] S0[236] sky130_fd_sc_hd__fah_1
x3[235] A[235] B[235] CARRY0[234] VSS VSS VCC VCC CARRY0[235] S0[235] sky130_fd_sc_hd__fah_1
x3[234] A[234] B[234] CARRY0[233] VSS VSS VCC VCC CARRY0[234] S0[234] sky130_fd_sc_hd__fah_1
x3[233] A[233] B[233] CARRY0[232] VSS VSS VCC VCC CARRY0[233] S0[233] sky130_fd_sc_hd__fah_1
x3[232] A[232] B[232] CARRY0[231] VSS VSS VCC VCC CARRY0[232] S0[232] sky130_fd_sc_hd__fah_1
x3[231] A[231] B[231] CARRY0[230] VSS VSS VCC VCC CARRY0[231] S0[231] sky130_fd_sc_hd__fah_1
x3[230] A[230] B[230] CARRY0[229] VSS VSS VCC VCC CARRY0[230] S0[230] sky130_fd_sc_hd__fah_1
x3[229] A[229] B[229] CARRY0[228] VSS VSS VCC VCC CARRY0[229] S0[229] sky130_fd_sc_hd__fah_1
x3[228] A[228] B[228] CARRY0[227] VSS VSS VCC VCC CARRY0[228] S0[228] sky130_fd_sc_hd__fah_1
x3[227] A[227] B[227] CARRY0[226] VSS VSS VCC VCC CARRY0[227] S0[227] sky130_fd_sc_hd__fah_1
x3[226] A[226] B[226] CARRY0[225] VSS VSS VCC VCC CARRY0[226] S0[226] sky130_fd_sc_hd__fah_1
x3[225] A[225] B[225] CARRY0[224] VSS VSS VCC VCC CARRY0[225] S0[225] sky130_fd_sc_hd__fah_1
x3[224] A[224] B[224] CARRY0[223] VSS VSS VCC VCC CARRY0[224] S0[224] sky130_fd_sc_hd__fah_1
x3[223] A[223] B[223] CARRY0[222] VSS VSS VCC VCC CARRY0[223] S0[223] sky130_fd_sc_hd__fah_1
x3[222] A[222] B[222] CARRY0[221] VSS VSS VCC VCC CARRY0[222] S0[222] sky130_fd_sc_hd__fah_1
x3[221] A[221] B[221] CARRY0[220] VSS VSS VCC VCC CARRY0[221] S0[221] sky130_fd_sc_hd__fah_1
x3[220] A[220] B[220] CARRY0[219] VSS VSS VCC VCC CARRY0[220] S0[220] sky130_fd_sc_hd__fah_1
x3[219] A[219] B[219] CARRY0[218] VSS VSS VCC VCC CARRY0[219] S0[219] sky130_fd_sc_hd__fah_1
x3[218] A[218] B[218] CARRY0[217] VSS VSS VCC VCC CARRY0[218] S0[218] sky130_fd_sc_hd__fah_1
x3[217] A[217] B[217] CARRY0[216] VSS VSS VCC VCC CARRY0[217] S0[217] sky130_fd_sc_hd__fah_1
x3[216] A[216] B[216] CARRY0[215] VSS VSS VCC VCC CARRY0[216] S0[216] sky130_fd_sc_hd__fah_1
x3[215] A[215] B[215] CARRY0[214] VSS VSS VCC VCC CARRY0[215] S0[215] sky130_fd_sc_hd__fah_1
x3[214] A[214] B[214] CARRY0[213] VSS VSS VCC VCC CARRY0[214] S0[214] sky130_fd_sc_hd__fah_1
x3[213] A[213] B[213] CARRY0[212] VSS VSS VCC VCC CARRY0[213] S0[213] sky130_fd_sc_hd__fah_1
x3[212] A[212] B[212] CARRY0[211] VSS VSS VCC VCC CARRY0[212] S0[212] sky130_fd_sc_hd__fah_1
x3[211] A[211] B[211] CARRY0[210] VSS VSS VCC VCC CARRY0[211] S0[211] sky130_fd_sc_hd__fah_1
x3[210] A[210] B[210] CARRY0[209] VSS VSS VCC VCC CARRY0[210] S0[210] sky130_fd_sc_hd__fah_1
x3[209] A[209] B[209] CARRY0[208] VSS VSS VCC VCC CARRY0[209] S0[209] sky130_fd_sc_hd__fah_1
x3[208] A[208] B[208] CARRY0[207] VSS VSS VCC VCC CARRY0[208] S0[208] sky130_fd_sc_hd__fah_1
x3[207] A[207] B[207] CARRY0[206] VSS VSS VCC VCC CARRY0[207] S0[207] sky130_fd_sc_hd__fah_1
x3[206] A[206] B[206] CARRY0[205] VSS VSS VCC VCC CARRY0[206] S0[206] sky130_fd_sc_hd__fah_1
x3[205] A[205] B[205] CARRY0[204] VSS VSS VCC VCC CARRY0[205] S0[205] sky130_fd_sc_hd__fah_1
x3[204] A[204] B[204] CARRY0[203] VSS VSS VCC VCC CARRY0[204] S0[204] sky130_fd_sc_hd__fah_1
x3[203] A[203] B[203] CARRY0[202] VSS VSS VCC VCC CARRY0[203] S0[203] sky130_fd_sc_hd__fah_1
x3[202] A[202] B[202] CARRY0[201] VSS VSS VCC VCC CARRY0[202] S0[202] sky130_fd_sc_hd__fah_1
x3[201] A[201] B[201] CARRY0[200] VSS VSS VCC VCC CARRY0[201] S0[201] sky130_fd_sc_hd__fah_1
x3[200] A[200] B[200] CARRY0[199] VSS VSS VCC VCC CARRY0[200] S0[200] sky130_fd_sc_hd__fah_1
x3[199] A[199] B[199] CARRY0[198] VSS VSS VCC VCC CARRY0[199] S0[199] sky130_fd_sc_hd__fah_1
x3[198] A[198] B[198] CARRY0[197] VSS VSS VCC VCC CARRY0[198] S0[198] sky130_fd_sc_hd__fah_1
x3[197] A[197] B[197] CARRY0[196] VSS VSS VCC VCC CARRY0[197] S0[197] sky130_fd_sc_hd__fah_1
x3[196] A[196] B[196] CARRY0[195] VSS VSS VCC VCC CARRY0[196] S0[196] sky130_fd_sc_hd__fah_1
x3[195] A[195] B[195] CARRY0[194] VSS VSS VCC VCC CARRY0[195] S0[195] sky130_fd_sc_hd__fah_1
x3[194] A[194] B[194] CARRY0[193] VSS VSS VCC VCC CARRY0[194] S0[194] sky130_fd_sc_hd__fah_1
x3[193] A[193] B[193] CARRY0[192] VSS VSS VCC VCC CARRY0[193] S0[193] sky130_fd_sc_hd__fah_1
x3[192] A[192] B[192] CARRY0[191] VSS VSS VCC VCC CARRY0[192] S0[192] sky130_fd_sc_hd__fah_1
x3[191] A[191] B[191] CARRY0[190] VSS VSS VCC VCC CARRY0[191] S0[191] sky130_fd_sc_hd__fah_1
x3[190] A[190] B[190] CARRY0[189] VSS VSS VCC VCC CARRY0[190] S0[190] sky130_fd_sc_hd__fah_1
x3[189] A[189] B[189] CARRY0[188] VSS VSS VCC VCC CARRY0[189] S0[189] sky130_fd_sc_hd__fah_1
x3[188] A[188] B[188] CARRY0[187] VSS VSS VCC VCC CARRY0[188] S0[188] sky130_fd_sc_hd__fah_1
x3[187] A[187] B[187] CARRY0[186] VSS VSS VCC VCC CARRY0[187] S0[187] sky130_fd_sc_hd__fah_1
x3[186] A[186] B[186] CARRY0[185] VSS VSS VCC VCC CARRY0[186] S0[186] sky130_fd_sc_hd__fah_1
x3[185] A[185] B[185] CARRY0[184] VSS VSS VCC VCC CARRY0[185] S0[185] sky130_fd_sc_hd__fah_1
x3[184] A[184] B[184] CARRY0[183] VSS VSS VCC VCC CARRY0[184] S0[184] sky130_fd_sc_hd__fah_1
x3[183] A[183] B[183] CARRY0[182] VSS VSS VCC VCC CARRY0[183] S0[183] sky130_fd_sc_hd__fah_1
x3[182] A[182] B[182] CARRY0[181] VSS VSS VCC VCC CARRY0[182] S0[182] sky130_fd_sc_hd__fah_1
x3[181] A[181] B[181] CARRY0[180] VSS VSS VCC VCC CARRY0[181] S0[181] sky130_fd_sc_hd__fah_1
x3[180] A[180] B[180] CARRY0[179] VSS VSS VCC VCC CARRY0[180] S0[180] sky130_fd_sc_hd__fah_1
x3[179] A[179] B[179] CARRY0[178] VSS VSS VCC VCC CARRY0[179] S0[179] sky130_fd_sc_hd__fah_1
x3[178] A[178] B[178] CARRY0[177] VSS VSS VCC VCC CARRY0[178] S0[178] sky130_fd_sc_hd__fah_1
x3[177] A[177] B[177] CARRY0[176] VSS VSS VCC VCC CARRY0[177] S0[177] sky130_fd_sc_hd__fah_1
x3[176] A[176] B[176] CARRY0[175] VSS VSS VCC VCC CARRY0[176] S0[176] sky130_fd_sc_hd__fah_1
x3[175] A[175] B[175] CARRY0[174] VSS VSS VCC VCC CARRY0[175] S0[175] sky130_fd_sc_hd__fah_1
x3[174] A[174] B[174] CARRY0[173] VSS VSS VCC VCC CARRY0[174] S0[174] sky130_fd_sc_hd__fah_1
x3[173] A[173] B[173] CARRY0[172] VSS VSS VCC VCC CARRY0[173] S0[173] sky130_fd_sc_hd__fah_1
x3[172] A[172] B[172] CARRY0[171] VSS VSS VCC VCC CARRY0[172] S0[172] sky130_fd_sc_hd__fah_1
x3[171] A[171] B[171] CARRY0[170] VSS VSS VCC VCC CARRY0[171] S0[171] sky130_fd_sc_hd__fah_1
x3[170] A[170] B[170] CARRY0[169] VSS VSS VCC VCC CARRY0[170] S0[170] sky130_fd_sc_hd__fah_1
x3[169] A[169] B[169] CARRY0[168] VSS VSS VCC VCC CARRY0[169] S0[169] sky130_fd_sc_hd__fah_1
x3[168] A[168] B[168] CARRY0[167] VSS VSS VCC VCC CARRY0[168] S0[168] sky130_fd_sc_hd__fah_1
x3[167] A[167] B[167] CARRY0[166] VSS VSS VCC VCC CARRY0[167] S0[167] sky130_fd_sc_hd__fah_1
x3[166] A[166] B[166] CARRY0[165] VSS VSS VCC VCC CARRY0[166] S0[166] sky130_fd_sc_hd__fah_1
x3[165] A[165] B[165] CARRY0[164] VSS VSS VCC VCC CARRY0[165] S0[165] sky130_fd_sc_hd__fah_1
x3[164] A[164] B[164] CARRY0[163] VSS VSS VCC VCC CARRY0[164] S0[164] sky130_fd_sc_hd__fah_1
x3[163] A[163] B[163] CARRY0[162] VSS VSS VCC VCC CARRY0[163] S0[163] sky130_fd_sc_hd__fah_1
x3[162] A[162] B[162] CARRY0[161] VSS VSS VCC VCC CARRY0[162] S0[162] sky130_fd_sc_hd__fah_1
x3[161] A[161] B[161] CARRY0[160] VSS VSS VCC VCC CARRY0[161] S0[161] sky130_fd_sc_hd__fah_1
x3[160] A[160] B[160] CARRY0[159] VSS VSS VCC VCC CARRY0[160] S0[160] sky130_fd_sc_hd__fah_1
x3[159] A[159] B[159] CARRY0[158] VSS VSS VCC VCC CARRY0[159] S0[159] sky130_fd_sc_hd__fah_1
x3[158] A[158] B[158] CARRY0[157] VSS VSS VCC VCC CARRY0[158] S0[158] sky130_fd_sc_hd__fah_1
x3[157] A[157] B[157] CARRY0[156] VSS VSS VCC VCC CARRY0[157] S0[157] sky130_fd_sc_hd__fah_1
x3[156] A[156] B[156] CARRY0[155] VSS VSS VCC VCC CARRY0[156] S0[156] sky130_fd_sc_hd__fah_1
x3[155] A[155] B[155] CARRY0[154] VSS VSS VCC VCC CARRY0[155] S0[155] sky130_fd_sc_hd__fah_1
x3[154] A[154] B[154] CARRY0[153] VSS VSS VCC VCC CARRY0[154] S0[154] sky130_fd_sc_hd__fah_1
x3[153] A[153] B[153] CARRY0[152] VSS VSS VCC VCC CARRY0[153] S0[153] sky130_fd_sc_hd__fah_1
x3[152] A[152] B[152] CARRY0[151] VSS VSS VCC VCC CARRY0[152] S0[152] sky130_fd_sc_hd__fah_1
x3[151] A[151] B[151] CARRY0[150] VSS VSS VCC VCC CARRY0[151] S0[151] sky130_fd_sc_hd__fah_1
x3[150] A[150] B[150] CARRY0[149] VSS VSS VCC VCC CARRY0[150] S0[150] sky130_fd_sc_hd__fah_1
x3[149] A[149] B[149] CARRY0[148] VSS VSS VCC VCC CARRY0[149] S0[149] sky130_fd_sc_hd__fah_1
x3[148] A[148] B[148] CARRY0[147] VSS VSS VCC VCC CARRY0[148] S0[148] sky130_fd_sc_hd__fah_1
x3[147] A[147] B[147] CARRY0[146] VSS VSS VCC VCC CARRY0[147] S0[147] sky130_fd_sc_hd__fah_1
x3[146] A[146] B[146] CARRY0[145] VSS VSS VCC VCC CARRY0[146] S0[146] sky130_fd_sc_hd__fah_1
x3[145] A[145] B[145] CARRY0[144] VSS VSS VCC VCC CARRY0[145] S0[145] sky130_fd_sc_hd__fah_1
x3[144] A[144] B[144] CARRY0[143] VSS VSS VCC VCC CARRY0[144] S0[144] sky130_fd_sc_hd__fah_1
x3[143] A[143] B[143] CARRY0[142] VSS VSS VCC VCC CARRY0[143] S0[143] sky130_fd_sc_hd__fah_1
x3[142] A[142] B[142] CARRY0[141] VSS VSS VCC VCC CARRY0[142] S0[142] sky130_fd_sc_hd__fah_1
x3[141] A[141] B[141] CARRY0[140] VSS VSS VCC VCC CARRY0[141] S0[141] sky130_fd_sc_hd__fah_1
x3[140] A[140] B[140] CARRY0[139] VSS VSS VCC VCC CARRY0[140] S0[140] sky130_fd_sc_hd__fah_1
x3[139] A[139] B[139] CARRY0[138] VSS VSS VCC VCC CARRY0[139] S0[139] sky130_fd_sc_hd__fah_1
x3[138] A[138] B[138] CARRY0[137] VSS VSS VCC VCC CARRY0[138] S0[138] sky130_fd_sc_hd__fah_1
x3[137] A[137] B[137] CARRY0[136] VSS VSS VCC VCC CARRY0[137] S0[137] sky130_fd_sc_hd__fah_1
x3[136] A[136] B[136] CARRY0[135] VSS VSS VCC VCC CARRY0[136] S0[136] sky130_fd_sc_hd__fah_1
x3[135] A[135] B[135] CARRY0[134] VSS VSS VCC VCC CARRY0[135] S0[135] sky130_fd_sc_hd__fah_1
x3[134] A[134] B[134] CARRY0[133] VSS VSS VCC VCC CARRY0[134] S0[134] sky130_fd_sc_hd__fah_1
x3[133] A[133] B[133] CARRY0[132] VSS VSS VCC VCC CARRY0[133] S0[133] sky130_fd_sc_hd__fah_1
x3[132] A[132] B[132] CARRY0[131] VSS VSS VCC VCC CARRY0[132] S0[132] sky130_fd_sc_hd__fah_1
x3[131] A[131] B[131] CARRY0[130] VSS VSS VCC VCC CARRY0[131] S0[131] sky130_fd_sc_hd__fah_1
x3[130] A[130] B[130] CARRY0[129] VSS VSS VCC VCC CARRY0[130] S0[130] sky130_fd_sc_hd__fah_1
x3[129] A[129] B[129] CARRY0[128] VSS VSS VCC VCC CARRY0[129] S0[129] sky130_fd_sc_hd__fah_1
x3[128] A[128] B[128] CARRY0[127] VSS VSS VCC VCC CARRY0[128] S0[128] sky130_fd_sc_hd__fah_1
x3[127] A[127] B[127] CARRY0[126] VSS VSS VCC VCC CARRY0[127] S0[127] sky130_fd_sc_hd__fah_1
x3[126] A[126] B[126] CARRY0[125] VSS VSS VCC VCC CARRY0[126] S0[126] sky130_fd_sc_hd__fah_1
x3[125] A[125] B[125] CARRY0[124] VSS VSS VCC VCC CARRY0[125] S0[125] sky130_fd_sc_hd__fah_1
x3[124] A[124] B[124] CARRY0[123] VSS VSS VCC VCC CARRY0[124] S0[124] sky130_fd_sc_hd__fah_1
x3[123] A[123] B[123] CARRY0[122] VSS VSS VCC VCC CARRY0[123] S0[123] sky130_fd_sc_hd__fah_1
x3[122] A[122] B[122] CARRY0[121] VSS VSS VCC VCC CARRY0[122] S0[122] sky130_fd_sc_hd__fah_1
x3[121] A[121] B[121] CARRY0[120] VSS VSS VCC VCC CARRY0[121] S0[121] sky130_fd_sc_hd__fah_1
x3[120] A[120] B[120] CARRY0[119] VSS VSS VCC VCC CARRY0[120] S0[120] sky130_fd_sc_hd__fah_1
x3[119] A[119] B[119] CARRY0[118] VSS VSS VCC VCC CARRY0[119] S0[119] sky130_fd_sc_hd__fah_1
x3[118] A[118] B[118] CARRY0[117] VSS VSS VCC VCC CARRY0[118] S0[118] sky130_fd_sc_hd__fah_1
x3[117] A[117] B[117] CARRY0[116] VSS VSS VCC VCC CARRY0[117] S0[117] sky130_fd_sc_hd__fah_1
x3[116] A[116] B[116] CARRY0[115] VSS VSS VCC VCC CARRY0[116] S0[116] sky130_fd_sc_hd__fah_1
x3[115] A[115] B[115] CARRY0[114] VSS VSS VCC VCC CARRY0[115] S0[115] sky130_fd_sc_hd__fah_1
x3[114] A[114] B[114] CARRY0[113] VSS VSS VCC VCC CARRY0[114] S0[114] sky130_fd_sc_hd__fah_1
x3[113] A[113] B[113] CARRY0[112] VSS VSS VCC VCC CARRY0[113] S0[113] sky130_fd_sc_hd__fah_1
x3[112] A[112] B[112] CARRY0[111] VSS VSS VCC VCC CARRY0[112] S0[112] sky130_fd_sc_hd__fah_1
x3[111] A[111] B[111] CARRY0[110] VSS VSS VCC VCC CARRY0[111] S0[111] sky130_fd_sc_hd__fah_1
x3[110] A[110] B[110] CARRY0[109] VSS VSS VCC VCC CARRY0[110] S0[110] sky130_fd_sc_hd__fah_1
x3[109] A[109] B[109] CARRY0[108] VSS VSS VCC VCC CARRY0[109] S0[109] sky130_fd_sc_hd__fah_1
x3[108] A[108] B[108] CARRY0[107] VSS VSS VCC VCC CARRY0[108] S0[108] sky130_fd_sc_hd__fah_1
x3[107] A[107] B[107] CARRY0[106] VSS VSS VCC VCC CARRY0[107] S0[107] sky130_fd_sc_hd__fah_1
x3[106] A[106] B[106] CARRY0[105] VSS VSS VCC VCC CARRY0[106] S0[106] sky130_fd_sc_hd__fah_1
x3[105] A[105] B[105] CARRY0[104] VSS VSS VCC VCC CARRY0[105] S0[105] sky130_fd_sc_hd__fah_1
x3[104] A[104] B[104] CARRY0[103] VSS VSS VCC VCC CARRY0[104] S0[104] sky130_fd_sc_hd__fah_1
x3[103] A[103] B[103] CARRY0[102] VSS VSS VCC VCC CARRY0[103] S0[103] sky130_fd_sc_hd__fah_1
x3[102] A[102] B[102] CARRY0[101] VSS VSS VCC VCC CARRY0[102] S0[102] sky130_fd_sc_hd__fah_1
x3[101] A[101] B[101] CARRY0[100] VSS VSS VCC VCC CARRY0[101] S0[101] sky130_fd_sc_hd__fah_1
x3[100] A[100] B[100] CARRY0[99] VSS VSS VCC VCC CARRY0[100] S0[100] sky130_fd_sc_hd__fah_1
x3[99] A[99] B[99] CARRY0[98] VSS VSS VCC VCC CARRY0[99] S0[99] sky130_fd_sc_hd__fah_1
x3[98] A[98] B[98] CARRY0[97] VSS VSS VCC VCC CARRY0[98] S0[98] sky130_fd_sc_hd__fah_1
x3[97] A[97] B[97] CARRY0[96] VSS VSS VCC VCC CARRY0[97] S0[97] sky130_fd_sc_hd__fah_1
x3[96] A[96] B[96] CARRY0[95] VSS VSS VCC VCC CARRY0[96] S0[96] sky130_fd_sc_hd__fah_1
x3[95] A[95] B[95] CARRY0[94] VSS VSS VCC VCC CARRY0[95] S0[95] sky130_fd_sc_hd__fah_1
x3[94] A[94] B[94] CARRY0[93] VSS VSS VCC VCC CARRY0[94] S0[94] sky130_fd_sc_hd__fah_1
x3[93] A[93] B[93] CARRY0[92] VSS VSS VCC VCC CARRY0[93] S0[93] sky130_fd_sc_hd__fah_1
x3[92] A[92] B[92] CARRY0[91] VSS VSS VCC VCC CARRY0[92] S0[92] sky130_fd_sc_hd__fah_1
x3[91] A[91] B[91] CARRY0[90] VSS VSS VCC VCC CARRY0[91] S0[91] sky130_fd_sc_hd__fah_1
x3[90] A[90] B[90] CARRY0[89] VSS VSS VCC VCC CARRY0[90] S0[90] sky130_fd_sc_hd__fah_1
x3[89] A[89] B[89] CARRY0[88] VSS VSS VCC VCC CARRY0[89] S0[89] sky130_fd_sc_hd__fah_1
x3[88] A[88] B[88] CARRY0[87] VSS VSS VCC VCC CARRY0[88] S0[88] sky130_fd_sc_hd__fah_1
x3[87] A[87] B[87] CARRY0[86] VSS VSS VCC VCC CARRY0[87] S0[87] sky130_fd_sc_hd__fah_1
x3[86] A[86] B[86] CARRY0[85] VSS VSS VCC VCC CARRY0[86] S0[86] sky130_fd_sc_hd__fah_1
x3[85] A[85] B[85] CARRY0[84] VSS VSS VCC VCC CARRY0[85] S0[85] sky130_fd_sc_hd__fah_1
x3[84] A[84] B[84] CARRY0[83] VSS VSS VCC VCC CARRY0[84] S0[84] sky130_fd_sc_hd__fah_1
x3[83] A[83] B[83] CARRY0[82] VSS VSS VCC VCC CARRY0[83] S0[83] sky130_fd_sc_hd__fah_1
x3[82] A[82] B[82] CARRY0[81] VSS VSS VCC VCC CARRY0[82] S0[82] sky130_fd_sc_hd__fah_1
x3[81] A[81] B[81] CARRY0[80] VSS VSS VCC VCC CARRY0[81] S0[81] sky130_fd_sc_hd__fah_1
x3[80] A[80] B[80] CARRY0[79] VSS VSS VCC VCC CARRY0[80] S0[80] sky130_fd_sc_hd__fah_1
x3[79] A[79] B[79] CARRY0[78] VSS VSS VCC VCC CARRY0[79] S0[79] sky130_fd_sc_hd__fah_1
x3[78] A[78] B[78] CARRY0[77] VSS VSS VCC VCC CARRY0[78] S0[78] sky130_fd_sc_hd__fah_1
x3[77] A[77] B[77] CARRY0[76] VSS VSS VCC VCC CARRY0[77] S0[77] sky130_fd_sc_hd__fah_1
x3[76] A[76] B[76] CARRY0[75] VSS VSS VCC VCC CARRY0[76] S0[76] sky130_fd_sc_hd__fah_1
x3[75] A[75] B[75] CARRY0[74] VSS VSS VCC VCC CARRY0[75] S0[75] sky130_fd_sc_hd__fah_1
x3[74] A[74] B[74] CARRY0[73] VSS VSS VCC VCC CARRY0[74] S0[74] sky130_fd_sc_hd__fah_1
x3[73] A[73] B[73] CARRY0[72] VSS VSS VCC VCC CARRY0[73] S0[73] sky130_fd_sc_hd__fah_1
x3[72] A[72] B[72] CARRY0[71] VSS VSS VCC VCC CARRY0[72] S0[72] sky130_fd_sc_hd__fah_1
x3[71] A[71] B[71] CARRY0[70] VSS VSS VCC VCC CARRY0[71] S0[71] sky130_fd_sc_hd__fah_1
x3[70] A[70] B[70] CARRY0[69] VSS VSS VCC VCC CARRY0[70] S0[70] sky130_fd_sc_hd__fah_1
x3[69] A[69] B[69] CARRY0[68] VSS VSS VCC VCC CARRY0[69] S0[69] sky130_fd_sc_hd__fah_1
x3[68] A[68] B[68] CARRY0[67] VSS VSS VCC VCC CARRY0[68] S0[68] sky130_fd_sc_hd__fah_1
x3[67] A[67] B[67] CARRY0[66] VSS VSS VCC VCC CARRY0[67] S0[67] sky130_fd_sc_hd__fah_1
x3[66] A[66] B[66] CARRY0[65] VSS VSS VCC VCC CARRY0[66] S0[66] sky130_fd_sc_hd__fah_1
x3[65] A[65] B[65] CARRY0[64] VSS VSS VCC VCC CARRY0[65] S0[65] sky130_fd_sc_hd__fah_1
x3[64] A[64] B[64] CARRY0[63] VSS VSS VCC VCC CARRY0[64] S0[64] sky130_fd_sc_hd__fah_1
x3[63] A[63] B[63] CARRY0[62] VSS VSS VCC VCC CARRY0[63] S0[63] sky130_fd_sc_hd__fah_1
x3[62] A[62] B[62] CARRY0[61] VSS VSS VCC VCC CARRY0[62] S0[62] sky130_fd_sc_hd__fah_1
x3[61] A[61] B[61] CARRY0[60] VSS VSS VCC VCC CARRY0[61] S0[61] sky130_fd_sc_hd__fah_1
x3[60] A[60] B[60] CARRY0[59] VSS VSS VCC VCC CARRY0[60] S0[60] sky130_fd_sc_hd__fah_1
x3[59] A[59] B[59] CARRY0[58] VSS VSS VCC VCC CARRY0[59] S0[59] sky130_fd_sc_hd__fah_1
x3[58] A[58] B[58] CARRY0[57] VSS VSS VCC VCC CARRY0[58] S0[58] sky130_fd_sc_hd__fah_1
x3[57] A[57] B[57] CARRY0[56] VSS VSS VCC VCC CARRY0[57] S0[57] sky130_fd_sc_hd__fah_1
x3[56] A[56] B[56] CARRY0[55] VSS VSS VCC VCC CARRY0[56] S0[56] sky130_fd_sc_hd__fah_1
x3[55] A[55] B[55] CARRY0[54] VSS VSS VCC VCC CARRY0[55] S0[55] sky130_fd_sc_hd__fah_1
x3[54] A[54] B[54] CARRY0[53] VSS VSS VCC VCC CARRY0[54] S0[54] sky130_fd_sc_hd__fah_1
x3[53] A[53] B[53] CARRY0[52] VSS VSS VCC VCC CARRY0[53] S0[53] sky130_fd_sc_hd__fah_1
x3[52] A[52] B[52] CARRY0[51] VSS VSS VCC VCC CARRY0[52] S0[52] sky130_fd_sc_hd__fah_1
x3[51] A[51] B[51] CARRY0[50] VSS VSS VCC VCC CARRY0[51] S0[51] sky130_fd_sc_hd__fah_1
x3[50] A[50] B[50] CARRY0[49] VSS VSS VCC VCC CARRY0[50] S0[50] sky130_fd_sc_hd__fah_1
x3[49] A[49] B[49] CARRY0[48] VSS VSS VCC VCC CARRY0[49] S0[49] sky130_fd_sc_hd__fah_1
x3[48] A[48] B[48] CARRY0[47] VSS VSS VCC VCC CARRY0[48] S0[48] sky130_fd_sc_hd__fah_1
x3[47] A[47] B[47] CARRY0[46] VSS VSS VCC VCC CARRY0[47] S0[47] sky130_fd_sc_hd__fah_1
x3[46] A[46] B[46] CARRY0[45] VSS VSS VCC VCC CARRY0[46] S0[46] sky130_fd_sc_hd__fah_1
x3[45] A[45] B[45] CARRY0[44] VSS VSS VCC VCC CARRY0[45] S0[45] sky130_fd_sc_hd__fah_1
x3[44] A[44] B[44] CARRY0[43] VSS VSS VCC VCC CARRY0[44] S0[44] sky130_fd_sc_hd__fah_1
x3[43] A[43] B[43] CARRY0[42] VSS VSS VCC VCC CARRY0[43] S0[43] sky130_fd_sc_hd__fah_1
x3[42] A[42] B[42] CARRY0[41] VSS VSS VCC VCC CARRY0[42] S0[42] sky130_fd_sc_hd__fah_1
x3[41] A[41] B[41] CARRY0[40] VSS VSS VCC VCC CARRY0[41] S0[41] sky130_fd_sc_hd__fah_1
x3[40] A[40] B[40] CARRY0[39] VSS VSS VCC VCC CARRY0[40] S0[40] sky130_fd_sc_hd__fah_1
x3[39] A[39] B[39] CARRY0[38] VSS VSS VCC VCC CARRY0[39] S0[39] sky130_fd_sc_hd__fah_1
x3[38] A[38] B[38] CARRY0[37] VSS VSS VCC VCC CARRY0[38] S0[38] sky130_fd_sc_hd__fah_1
x3[37] A[37] B[37] CARRY0[36] VSS VSS VCC VCC CARRY0[37] S0[37] sky130_fd_sc_hd__fah_1
x3[36] A[36] B[36] CARRY0[35] VSS VSS VCC VCC CARRY0[36] S0[36] sky130_fd_sc_hd__fah_1
x3[35] A[35] B[35] CARRY0[34] VSS VSS VCC VCC CARRY0[35] S0[35] sky130_fd_sc_hd__fah_1
x3[34] A[34] B[34] CARRY0[33] VSS VSS VCC VCC CARRY0[34] S0[34] sky130_fd_sc_hd__fah_1
x3[33] A[33] B[33] CARRY0[32] VSS VSS VCC VCC CARRY0[33] S0[33] sky130_fd_sc_hd__fah_1
x3[32] A[32] B[32] CARRY0[31] VSS VSS VCC VCC CARRY0[32] S0[32] sky130_fd_sc_hd__fah_1
x3[31] A[31] B[31] CARRY0[30] VSS VSS VCC VCC CARRY0[31] S0[31] sky130_fd_sc_hd__fah_1
x3[30] A[30] B[30] CARRY0[29] VSS VSS VCC VCC CARRY0[30] S0[30] sky130_fd_sc_hd__fah_1
x3[29] A[29] B[29] CARRY0[28] VSS VSS VCC VCC CARRY0[29] S0[29] sky130_fd_sc_hd__fah_1
x3[28] A[28] B[28] CARRY0[27] VSS VSS VCC VCC CARRY0[28] S0[28] sky130_fd_sc_hd__fah_1
x3[27] A[27] B[27] CARRY0[26] VSS VSS VCC VCC CARRY0[27] S0[27] sky130_fd_sc_hd__fah_1
x3[26] A[26] B[26] CARRY0[25] VSS VSS VCC VCC CARRY0[26] S0[26] sky130_fd_sc_hd__fah_1
x3[25] A[25] B[25] CARRY0[24] VSS VSS VCC VCC CARRY0[25] S0[25] sky130_fd_sc_hd__fah_1
x3[24] A[24] B[24] CARRY0[23] VSS VSS VCC VCC CARRY0[24] S0[24] sky130_fd_sc_hd__fah_1
x3[23] A[23] B[23] CARRY0[22] VSS VSS VCC VCC CARRY0[23] S0[23] sky130_fd_sc_hd__fah_1
x3[22] A[22] B[22] CARRY0[21] VSS VSS VCC VCC CARRY0[22] S0[22] sky130_fd_sc_hd__fah_1
x3[21] A[21] B[21] CARRY0[20] VSS VSS VCC VCC CARRY0[21] S0[21] sky130_fd_sc_hd__fah_1
x3[20] A[20] B[20] CARRY0[19] VSS VSS VCC VCC CARRY0[20] S0[20] sky130_fd_sc_hd__fah_1
x3[19] A[19] B[19] CARRY0[18] VSS VSS VCC VCC CARRY0[19] S0[19] sky130_fd_sc_hd__fah_1
x3[18] A[18] B[18] CARRY0[17] VSS VSS VCC VCC CARRY0[18] S0[18] sky130_fd_sc_hd__fah_1
x3[17] A[17] B[17] CARRY0[16] VSS VSS VCC VCC CARRY0[17] S0[17] sky130_fd_sc_hd__fah_1
x3[16] A[16] B[16] CARRY0[15] VSS VSS VCC VCC CARRY0[16] S0[16] sky130_fd_sc_hd__fah_1
x3[15] A[15] B[15] CARRY0[14] VSS VSS VCC VCC CARRY0[15] S0[15] sky130_fd_sc_hd__fah_1
x3[14] A[14] B[14] CARRY0[13] VSS VSS VCC VCC CARRY0[14] S0[14] sky130_fd_sc_hd__fah_1
x3[13] A[13] B[13] CARRY0[12] VSS VSS VCC VCC CARRY0[13] S0[13] sky130_fd_sc_hd__fah_1
x3[12] A[12] B[12] CARRY0[11] VSS VSS VCC VCC CARRY0[12] S0[12] sky130_fd_sc_hd__fah_1
x3[11] A[11] B[11] CARRY0[10] VSS VSS VCC VCC CARRY0[11] S0[11] sky130_fd_sc_hd__fah_1
x3[10] A[10] B[10] CARRY0[9] VSS VSS VCC VCC CARRY0[10] S0[10] sky130_fd_sc_hd__fah_1
x3[9] A[9] B[9] CARRY0[8] VSS VSS VCC VCC CARRY0[9] S0[9] sky130_fd_sc_hd__fah_1
x3[8] A[8] B[8] CARRY0[7] VSS VSS VCC VCC CARRY0[8] S0[8] sky130_fd_sc_hd__fah_1
x3[7] A[7] B[7] CARRY0[6] VSS VSS VCC VCC CARRY0[7] S0[7] sky130_fd_sc_hd__fah_1
x3[6] A[6] B[6] CARRY0[5] VSS VSS VCC VCC CARRY0[6] S0[6] sky130_fd_sc_hd__fah_1
x3[5] A[5] B[5] CARRY0[4] VSS VSS VCC VCC CARRY0[5] S0[5] sky130_fd_sc_hd__fah_1
x3[4] A[4] B[4] CARRY0[3] VSS VSS VCC VCC CARRY0[4] S0[4] sky130_fd_sc_hd__fah_1
x3[3] A[3] B[3] CARRY0[2] VSS VSS VCC VCC CARRY0[3] S0[3] sky130_fd_sc_hd__fah_1
x3[2] A[2] B[2] CARRY0[1] VSS VSS VCC VCC CARRY0[2] S0[2] sky130_fd_sc_hd__fah_1
x3[1] A[1] B[1] CARRY0[0] VSS VSS VCC VCC CARRY0[1] S0[1] sky130_fd_sc_hd__fah_1
x3[0] A[0] B[0] CIN VSS VSS VCC VCC CARRY0[0] S0[0] sky130_fd_sc_hd__fah_1
x1 A[255] A[254] A[253] A[252] A[251] A[250] A[249] A[248] A[247] A[246] A[245] A[244] A[243] A[242]
+ A[241] A[240] A[239] A[238] A[237] A[236] A[235] A[234] A[233] A[232] A[231] A[230] A[229] A[228] A[227]
+ A[226] A[225] A[224] A[223] A[222] A[221] A[220] A[219] A[218] A[217] A[216] A[215] A[214] A[213] A[212]
+ A[211] A[210] A[209] A[208] A[207] A[206] A[205] A[204] A[203] A[202] A[201] A[200] A[199] A[198] A[197]
+ A[196] A[195] A[194] A[193] A[192] A[191] A[190] A[189] A[188] A[187] A[186] A[185] A[184] A[183] A[182]
+ A[181] A[180] A[179] A[178] A[177] A[176] A[175] A[174] A[173] A[172] A[171] A[170] A[169] A[168] A[167]
+ A[166] A[165] A[164] A[163] A[162] A[161] A[160] A[159] A[158] A[157] A[156] A[155] A[154] A[153] A[152]
+ A[151] A[150] A[149] A[148] A[147] A[146] A[145] A[144] A[143] A[142] A[141] A[140] A[139] A[138] A[137]
+ A[136] A[135] A[134] A[133] A[132] A[131] A[130] A[129] A[128] A[127] A[126] A[125] A[124] A[123] A[122]
+ A[121] A[120] A[119] A[118] A[117] A[116] A[115] A[114] A[113] A[112] A[111] A[110] A[109] A[108] A[107]
+ A[106] A[105] A[104] A[103] A[102] A[101] A[100] A[99] A[98] A[97] A[96] A[95] A[94] A[93] A[92] A[91]
+ A[90] A[89] A[88] A[87] A[86] A[85] A[84] A[83] A[82] A[81] A[80] A[79] A[78] A[77] A[76] A[75] A[74]
+ A[73] A[72] A[71] A[70] A[69] A[68] A[67] A[66] A[65] A[64] A[63] A[62] A[61] A[60] A[59] A[58] A[57]
+ A[56] A[55] A[54] A[53] A[52] A[51] A[50] A[49] A[48] A[47] A[46] A[45] A[44] A[43] A[42] A[41] A[40]
+ A[39] A[38] A[37] A[36] A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5]
+ A[4] A[3] A[2] A[1] A[0] S3[255] S3[254] S3[253] S3[252] S3[251] S3[250] S3[249] S3[248] S3[247] S3[246]
+ S3[245] S3[244] S3[243] S3[242] S3[241] S3[240] S3[239] S3[238] S3[237] S3[236] S3[235] S3[234] S3[233]
+ S3[232] S3[231] S3[230] S3[229] S3[228] S3[227] S3[226] S3[225] S3[224] S3[223] S3[222] S3[221] S3[220]
+ S3[219] S3[218] S3[217] S3[216] S3[215] S3[214] S3[213] S3[212] S3[211] S3[210] S3[209] S3[208] S3[207]
+ S3[206] S3[205] S3[204] S3[203] S3[202] S3[201] S3[200] S3[199] S3[198] S3[197] S3[196] S3[195] S3[194]
+ S3[193] S3[192] S3[191] S3[190] S3[189] S3[188] S3[187] S3[186] S3[185] S3[184] S3[183] S3[182] S3[181]
+ S3[180] S3[179] S3[178] S3[177] S3[176] S3[175] S3[174] S3[173] S3[172] S3[171] S3[170] S3[169] S3[168]
+ S3[167] S3[166] S3[165] S3[164] S3[163] S3[162] S3[161] S3[160] S3[159] S3[158] S3[157] S3[156] S3[155]
+ S3[154] S3[153] S3[152] S3[151] S3[150] S3[149] S3[148] S3[147] S3[146] S3[145] S3[144] S3[143] S3[142]
+ S3[141] S3[140] S3[139] S3[138] S3[137] S3[136] S3[135] S3[134] S3[133] S3[132] S3[131] S3[130] S3[129]
+ S3[128] S3[127] S3[126] S3[125] S3[124] S3[123] S3[122] S3[121] S3[120] S3[119] S3[118] S3[117] S3[116]
+ S3[115] S3[114] S3[113] S3[112] S3[111] S3[110] S3[109] S3[108] S3[107] S3[106] S3[105] S3[104] S3[103]
+ S3[102] S3[101] S3[100] S3[99] S3[98] S3[97] S3[96] S3[95] S3[94] S3[93] S3[92] S3[91] S3[90] S3[89] S3[88]
+ S3[87] S3[86] S3[85] S3[84] S3[83] S3[82] S3[81] S3[80] S3[79] S3[78] S3[77] S3[76] S3[75] S3[74] S3[73]
+ S3[72] S3[71] S3[70] S3[69] S3[68] S3[67] S3[66] S3[65] S3[64] S3[63] S3[62] S3[61] S3[60] S3[59] S3[58]
+ S3[57] S3[56] S3[55] S3[54] S3[53] S3[52] S3[51] S3[50] S3[49] S3[48] S3[47] S3[46] S3[45] S3[44] S3[43]
+ S3[42] S3[41] S3[40] S3[39] S3[38] S3[37] S3[36] S3[35] S3[34] S3[33] S3[32] S3[31] S3[30] S3[29] S3[28]
+ S3[27] S3[26] S3[25] S3[24] S3[23] S3[22] S3[21] S3[20] S3[19] S3[18] S3[17] S3[16] S3[15] S3[14] S3[13]
+ S3[12] S3[11] S3[10] S3[9] S3[8] S3[7] S3[6] S3[5] S3[4] S3[3] S3[2] S3[1] S3[0] B[255] B[254] B[253]
+ B[252] B[251] B[250] B[249] B[248] B[247] B[246] B[245] B[244] B[243] B[242] B[241] B[240] B[239] B[238]
+ B[237] B[236] B[235] B[234] B[233] B[232] B[231] B[230] B[229] B[228] B[227] B[226] B[225] B[224] B[223]
+ B[222] B[221] B[220] B[219] B[218] B[217] B[216] B[215] B[214] B[213] B[212] B[211] B[210] B[209] B[208]
+ B[207] B[206] B[205] B[204] B[203] B[202] B[201] B[200] B[199] B[198] B[197] B[196] B[195] B[194] B[193]
+ B[192] B[191] B[190] B[189] B[188] B[187] B[186] B[185] B[184] B[183] B[182] B[181] B[180] B[179] B[178]
+ B[177] B[176] B[175] B[174] B[173] B[172] B[171] B[170] B[169] B[168] B[167] B[166] B[165] B[164] B[163]
+ B[162] B[161] B[160] B[159] B[158] B[157] B[156] B[155] B[154] B[153] B[152] B[151] B[150] B[149] B[148]
+ B[147] B[146] B[145] B[144] B[143] B[142] B[141] B[140] B[139] B[138] B[137] B[136] B[135] B[134] B[133]
+ B[132] B[131] B[130] B[129] B[128] B[127] B[126] B[125] B[124] B[123] B[122] B[121] B[120] B[119] B[118]
+ B[117] B[116] B[115] B[114] B[113] B[112] B[111] B[110] B[109] B[108] B[107] B[106] B[105] B[104] B[103]
+ B[102] B[101] B[100] B[99] B[98] B[97] B[96] B[95] B[94] B[93] B[92] B[91] B[90] B[89] B[88] B[87] B[86]
+ B[85] B[84] B[83] B[82] B[81] B[80] B[79] B[78] B[77] B[76] B[75] B[74] B[73] B[72] B[71] B[70] B[69]
+ B[68] B[67] B[66] B[65] B[64] B[63] B[62] B[61] B[60] B[59] B[58] B[57] B[56] B[55] B[54] B[53] B[52]
+ B[51] B[50] B[49] B[48] B[47] B[46] B[45] B[44] B[43] B[42] B[41] B[40] B[39] B[38] B[37] B[36] B[35]
+ B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18]
+ B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] COUT3
+ SG3 CIN SP3 adder_256bit
* noconn VCC
* noconn VSS
.save v(a[255])
.save v(a[254])
.save v(a[253])
.save v(a[252])
.save v(a[251])
.save v(a[250])
.save v(a[249])
.save v(a[248])
.save v(a[247])
.save v(a[246])
.save v(a[245])
.save v(a[244])
.save v(a[243])
.save v(a[242])
.save v(a[241])
.save v(a[240])
.save v(a[239])
.save v(a[238])
.save v(a[237])
.save v(a[236])
.save v(a[235])
.save v(a[234])
.save v(a[233])
.save v(a[232])
.save v(a[231])
.save v(a[230])
.save v(a[229])
.save v(a[228])
.save v(a[227])
.save v(a[226])
.save v(a[225])
.save v(a[224])
.save v(a[223])
.save v(a[222])
.save v(a[221])
.save v(a[220])
.save v(a[219])
.save v(a[218])
.save v(a[217])
.save v(a[216])
.save v(a[215])
.save v(a[214])
.save v(a[213])
.save v(a[212])
.save v(a[211])
.save v(a[210])
.save v(a[209])
.save v(a[208])
.save v(a[207])
.save v(a[206])
.save v(a[205])
.save v(a[204])
.save v(a[203])
.save v(a[202])
.save v(a[201])
.save v(a[200])
.save v(a[199])
.save v(a[198])
.save v(a[197])
.save v(a[196])
.save v(a[195])
.save v(a[194])
.save v(a[193])
.save v(a[192])
.save v(a[191])
.save v(a[190])
.save v(a[189])
.save v(a[188])
.save v(a[187])
.save v(a[186])
.save v(a[185])
.save v(a[184])
.save v(a[183])
.save v(a[182])
.save v(a[181])
.save v(a[180])
.save v(a[179])
.save v(a[178])
.save v(a[177])
.save v(a[176])
.save v(a[175])
.save v(a[174])
.save v(a[173])
.save v(a[172])
.save v(a[171])
.save v(a[170])
.save v(a[169])
.save v(a[168])
.save v(a[167])
.save v(a[166])
.save v(a[165])
.save v(a[164])
.save v(a[163])
.save v(a[162])
.save v(a[161])
.save v(a[160])
.save v(a[159])
.save v(a[158])
.save v(a[157])
.save v(a[156])
.save v(a[155])
.save v(a[154])
.save v(a[153])
.save v(a[152])
.save v(a[151])
.save v(a[150])
.save v(a[149])
.save v(a[148])
.save v(a[147])
.save v(a[146])
.save v(a[145])
.save v(a[144])
.save v(a[143])
.save v(a[142])
.save v(a[141])
.save v(a[140])
.save v(a[139])
.save v(a[138])
.save v(a[137])
.save v(a[136])
.save v(a[135])
.save v(a[134])
.save v(a[133])
.save v(a[132])
.save v(a[131])
.save v(a[130])
.save v(a[129])
.save v(a[128])
.save v(a[127])
.save v(a[126])
.save v(a[125])
.save v(a[124])
.save v(a[123])
.save v(a[122])
.save v(a[121])
.save v(a[120])
.save v(a[119])
.save v(a[118])
.save v(a[117])
.save v(a[116])
.save v(a[115])
.save v(a[114])
.save v(a[113])
.save v(a[112])
.save v(a[111])
.save v(a[110])
.save v(a[109])
.save v(a[108])
.save v(a[107])
.save v(a[106])
.save v(a[105])
.save v(a[104])
.save v(a[103])
.save v(a[102])
.save v(a[101])
.save v(a[100])
.save v(a[99])
.save v(a[98])
.save v(a[97])
.save v(a[96])
.save v(a[95])
.save v(a[94])
.save v(a[93])
.save v(a[92])
.save v(a[91])
.save v(a[90])
.save v(a[89])
.save v(a[88])
.save v(a[87])
.save v(a[86])
.save v(a[85])
.save v(a[84])
.save v(a[83])
.save v(a[82])
.save v(a[81])
.save v(a[80])
.save v(a[79])
.save v(a[78])
.save v(a[77])
.save v(a[76])
.save v(a[75])
.save v(a[74])
.save v(a[73])
.save v(a[72])
.save v(a[71])
.save v(a[70])
.save v(a[69])
.save v(a[68])
.save v(a[67])
.save v(a[66])
.save v(a[65])
.save v(a[64])
.save v(a[63])
.save v(a[62])
.save v(a[61])
.save v(a[60])
.save v(a[59])
.save v(a[58])
.save v(a[57])
.save v(a[56])
.save v(a[55])
.save v(a[54])
.save v(a[53])
.save v(a[52])
.save v(a[51])
.save v(a[50])
.save v(a[49])
.save v(a[48])
.save v(a[47])
.save v(a[46])
.save v(a[45])
.save v(a[44])
.save v(a[43])
.save v(a[42])
.save v(a[41])
.save v(a[40])
.save v(a[39])
.save v(a[38])
.save v(a[37])
.save v(a[36])
.save v(a[35])
.save v(a[34])
.save v(a[33])
.save v(a[32])
.save v(a[31])
.save v(a[30])
.save v(a[29])
.save v(a[28])
.save v(a[27])
.save v(a[26])
.save v(a[25])
.save v(a[24])
.save v(a[23])
.save v(a[22])
.save v(a[21])
.save v(a[20])
.save v(a[19])
.save v(a[18])
.save v(a[17])
.save v(a[16])
.save v(a[15])
.save v(a[14])
.save v(a[13])
.save v(a[12])
.save v(a[11])
.save v(a[10])
.save v(a[9])
.save v(a[8])
.save v(a[7])
.save v(a[6])
.save v(a[5])
.save v(a[4])
.save v(a[3])
.save v(a[2])
.save v(a[1])
.save v(a[0])
.save v(b[255])
.save v(b[254])
.save v(b[253])
.save v(b[252])
.save v(b[251])
.save v(b[250])
.save v(b[249])
.save v(b[248])
.save v(b[247])
.save v(b[246])
.save v(b[245])
.save v(b[244])
.save v(b[243])
.save v(b[242])
.save v(b[241])
.save v(b[240])
.save v(b[239])
.save v(b[238])
.save v(b[237])
.save v(b[236])
.save v(b[235])
.save v(b[234])
.save v(b[233])
.save v(b[232])
.save v(b[231])
.save v(b[230])
.save v(b[229])
.save v(b[228])
.save v(b[227])
.save v(b[226])
.save v(b[225])
.save v(b[224])
.save v(b[223])
.save v(b[222])
.save v(b[221])
.save v(b[220])
.save v(b[219])
.save v(b[218])
.save v(b[217])
.save v(b[216])
.save v(b[215])
.save v(b[214])
.save v(b[213])
.save v(b[212])
.save v(b[211])
.save v(b[210])
.save v(b[209])
.save v(b[208])
.save v(b[207])
.save v(b[206])
.save v(b[205])
.save v(b[204])
.save v(b[203])
.save v(b[202])
.save v(b[201])
.save v(b[200])
.save v(b[199])
.save v(b[198])
.save v(b[197])
.save v(b[196])
.save v(b[195])
.save v(b[194])
.save v(b[193])
.save v(b[192])
.save v(b[191])
.save v(b[190])
.save v(b[189])
.save v(b[188])
.save v(b[187])
.save v(b[186])
.save v(b[185])
.save v(b[184])
.save v(b[183])
.save v(b[182])
.save v(b[181])
.save v(b[180])
.save v(b[179])
.save v(b[178])
.save v(b[177])
.save v(b[176])
.save v(b[175])
.save v(b[174])
.save v(b[173])
.save v(b[172])
.save v(b[171])
.save v(b[170])
.save v(b[169])
.save v(b[168])
.save v(b[167])
.save v(b[166])
.save v(b[165])
.save v(b[164])
.save v(b[163])
.save v(b[162])
.save v(b[161])
.save v(b[160])
.save v(b[159])
.save v(b[158])
.save v(b[157])
.save v(b[156])
.save v(b[155])
.save v(b[154])
.save v(b[153])
.save v(b[152])
.save v(b[151])
.save v(b[150])
.save v(b[149])
.save v(b[148])
.save v(b[147])
.save v(b[146])
.save v(b[145])
.save v(b[144])
.save v(b[143])
.save v(b[142])
.save v(b[141])
.save v(b[140])
.save v(b[139])
.save v(b[138])
.save v(b[137])
.save v(b[136])
.save v(b[135])
.save v(b[134])
.save v(b[133])
.save v(b[132])
.save v(b[131])
.save v(b[130])
.save v(b[129])
.save v(b[128])
.save v(b[127])
.save v(b[126])
.save v(b[125])
.save v(b[124])
.save v(b[123])
.save v(b[122])
.save v(b[121])
.save v(b[120])
.save v(b[119])
.save v(b[118])
.save v(b[117])
.save v(b[116])
.save v(b[115])
.save v(b[114])
.save v(b[113])
.save v(b[112])
.save v(b[111])
.save v(b[110])
.save v(b[109])
.save v(b[108])
.save v(b[107])
.save v(b[106])
.save v(b[105])
.save v(b[104])
.save v(b[103])
.save v(b[102])
.save v(b[101])
.save v(b[100])
.save v(b[99])
.save v(b[98])
.save v(b[97])
.save v(b[96])
.save v(b[95])
.save v(b[94])
.save v(b[93])
.save v(b[92])
.save v(b[91])
.save v(b[90])
.save v(b[89])
.save v(b[88])
.save v(b[87])
.save v(b[86])
.save v(b[85])
.save v(b[84])
.save v(b[83])
.save v(b[82])
.save v(b[81])
.save v(b[80])
.save v(b[79])
.save v(b[78])
.save v(b[77])
.save v(b[76])
.save v(b[75])
.save v(b[74])
.save v(b[73])
.save v(b[72])
.save v(b[71])
.save v(b[70])
.save v(b[69])
.save v(b[68])
.save v(b[67])
.save v(b[66])
.save v(b[65])
.save v(b[64])
.save v(b[63])
.save v(b[62])
.save v(b[61])
.save v(b[60])
.save v(b[59])
.save v(b[58])
.save v(b[57])
.save v(b[56])
.save v(b[55])
.save v(b[54])
.save v(b[53])
.save v(b[52])
.save v(b[51])
.save v(b[50])
.save v(b[49])
.save v(b[48])
.save v(b[47])
.save v(b[46])
.save v(b[45])
.save v(b[44])
.save v(b[43])
.save v(b[42])
.save v(b[41])
.save v(b[40])
.save v(b[39])
.save v(b[38])
.save v(b[37])
.save v(b[36])
.save v(b[35])
.save v(b[34])
.save v(b[33])
.save v(b[32])
.save v(b[31])
.save v(b[30])
.save v(b[29])
.save v(b[28])
.save v(b[27])
.save v(b[26])
.save v(b[25])
.save v(b[24])
.save v(b[23])
.save v(b[22])
.save v(b[21])
.save v(b[20])
.save v(b[19])
.save v(b[18])
.save v(b[17])
.save v(b[16])
.save v(b[15])
.save v(b[14])
.save v(b[13])
.save v(b[12])
.save v(b[11])
.save v(b[10])
.save v(b[9])
.save v(b[8])
.save v(b[7])
.save v(b[6])
.save v(b[5])
.save v(b[4])
.save v(b[3])
.save v(b[2])
.save v(b[1])
.save v(b[0])
.save v(cin)
.save v(s3[255])
.save v(s3[254])
.save v(s3[253])
.save v(s3[252])
.save v(s3[251])
.save v(s3[250])
.save v(s3[249])
.save v(s3[248])
.save v(s3[247])
.save v(s3[246])
.save v(s3[245])
.save v(s3[244])
.save v(s3[243])
.save v(s3[242])
.save v(s3[241])
.save v(s3[240])
.save v(s3[239])
.save v(s3[238])
.save v(s3[237])
.save v(s3[236])
.save v(s3[235])
.save v(s3[234])
.save v(s3[233])
.save v(s3[232])
.save v(s3[231])
.save v(s3[230])
.save v(s3[229])
.save v(s3[228])
.save v(s3[227])
.save v(s3[226])
.save v(s3[225])
.save v(s3[224])
.save v(s3[223])
.save v(s3[222])
.save v(s3[221])
.save v(s3[220])
.save v(s3[219])
.save v(s3[218])
.save v(s3[217])
.save v(s3[216])
.save v(s3[215])
.save v(s3[214])
.save v(s3[213])
.save v(s3[212])
.save v(s3[211])
.save v(s3[210])
.save v(s3[209])
.save v(s3[208])
.save v(s3[207])
.save v(s3[206])
.save v(s3[205])
.save v(s3[204])
.save v(s3[203])
.save v(s3[202])
.save v(s3[201])
.save v(s3[200])
.save v(s3[199])
.save v(s3[198])
.save v(s3[197])
.save v(s3[196])
.save v(s3[195])
.save v(s3[194])
.save v(s3[193])
.save v(s3[192])
.save v(s3[191])
.save v(s3[190])
.save v(s3[189])
.save v(s3[188])
.save v(s3[187])
.save v(s3[186])
.save v(s3[185])
.save v(s3[184])
.save v(s3[183])
.save v(s3[182])
.save v(s3[181])
.save v(s3[180])
.save v(s3[179])
.save v(s3[178])
.save v(s3[177])
.save v(s3[176])
.save v(s3[175])
.save v(s3[174])
.save v(s3[173])
.save v(s3[172])
.save v(s3[171])
.save v(s3[170])
.save v(s3[169])
.save v(s3[168])
.save v(s3[167])
.save v(s3[166])
.save v(s3[165])
.save v(s3[164])
.save v(s3[163])
.save v(s3[162])
.save v(s3[161])
.save v(s3[160])
.save v(s3[159])
.save v(s3[158])
.save v(s3[157])
.save v(s3[156])
.save v(s3[155])
.save v(s3[154])
.save v(s3[153])
.save v(s3[152])
.save v(s3[151])
.save v(s3[150])
.save v(s3[149])
.save v(s3[148])
.save v(s3[147])
.save v(s3[146])
.save v(s3[145])
.save v(s3[144])
.save v(s3[143])
.save v(s3[142])
.save v(s3[141])
.save v(s3[140])
.save v(s3[139])
.save v(s3[138])
.save v(s3[137])
.save v(s3[136])
.save v(s3[135])
.save v(s3[134])
.save v(s3[133])
.save v(s3[132])
.save v(s3[131])
.save v(s3[130])
.save v(s3[129])
.save v(s3[128])
.save v(s3[127])
.save v(s3[126])
.save v(s3[125])
.save v(s3[124])
.save v(s3[123])
.save v(s3[122])
.save v(s3[121])
.save v(s3[120])
.save v(s3[119])
.save v(s3[118])
.save v(s3[117])
.save v(s3[116])
.save v(s3[115])
.save v(s3[114])
.save v(s3[113])
.save v(s3[112])
.save v(s3[111])
.save v(s3[110])
.save v(s3[109])
.save v(s3[108])
.save v(s3[107])
.save v(s3[106])
.save v(s3[105])
.save v(s3[104])
.save v(s3[103])
.save v(s3[102])
.save v(s3[101])
.save v(s3[100])
.save v(s3[99])
.save v(s3[98])
.save v(s3[97])
.save v(s3[96])
.save v(s3[95])
.save v(s3[94])
.save v(s3[93])
.save v(s3[92])
.save v(s3[91])
.save v(s3[90])
.save v(s3[89])
.save v(s3[88])
.save v(s3[87])
.save v(s3[86])
.save v(s3[85])
.save v(s3[84])
.save v(s3[83])
.save v(s3[82])
.save v(s3[81])
.save v(s3[80])
.save v(s3[79])
.save v(s3[78])
.save v(s3[77])
.save v(s3[76])
.save v(s3[75])
.save v(s3[74])
.save v(s3[73])
.save v(s3[72])
.save v(s3[71])
.save v(s3[70])
.save v(s3[69])
.save v(s3[68])
.save v(s3[67])
.save v(s3[66])
.save v(s3[65])
.save v(s3[64])
.save v(s3[63])
.save v(s3[62])
.save v(s3[61])
.save v(s3[60])
.save v(s3[59])
.save v(s3[58])
.save v(s3[57])
.save v(s3[56])
.save v(s3[55])
.save v(s3[54])
.save v(s3[53])
.save v(s3[52])
.save v(s3[51])
.save v(s3[50])
.save v(s3[49])
.save v(s3[48])
.save v(s3[47])
.save v(s3[46])
.save v(s3[45])
.save v(s3[44])
.save v(s3[43])
.save v(s3[42])
.save v(s3[41])
.save v(s3[40])
.save v(s3[39])
.save v(s3[38])
.save v(s3[37])
.save v(s3[36])
.save v(s3[35])
.save v(s3[34])
.save v(s3[33])
.save v(s3[32])
.save v(s3[31])
.save v(s3[30])
.save v(s3[29])
.save v(s3[28])
.save v(s3[27])
.save v(s3[26])
.save v(s3[25])
.save v(s3[24])
.save v(s3[23])
.save v(s3[22])
.save v(s3[21])
.save v(s3[20])
.save v(s3[19])
.save v(s3[18])
.save v(s3[17])
.save v(s3[16])
.save v(s3[15])
.save v(s3[14])
.save v(s3[13])
.save v(s3[12])
.save v(s3[11])
.save v(s3[10])
.save v(s3[9])
.save v(s3[8])
.save v(s3[7])
.save v(s3[6])
.save v(s3[5])
.save v(s3[4])
.save v(s3[3])
.save v(s3[2])
.save v(s3[1])
.save v(s3[0])
.save v(cout3)
.save v(carry0[255])
.save v(carry0[254])
.save v(carry0[253])
.save v(carry0[252])
.save v(carry0[251])
.save v(carry0[250])
.save v(carry0[249])
.save v(carry0[248])
.save v(carry0[247])
.save v(carry0[246])
.save v(carry0[245])
.save v(carry0[244])
.save v(carry0[243])
.save v(carry0[242])
.save v(carry0[241])
.save v(carry0[240])
.save v(carry0[239])
.save v(carry0[238])
.save v(carry0[237])
.save v(carry0[236])
.save v(carry0[235])
.save v(carry0[234])
.save v(carry0[233])
.save v(carry0[232])
.save v(carry0[231])
.save v(carry0[230])
.save v(carry0[229])
.save v(carry0[228])
.save v(carry0[227])
.save v(carry0[226])
.save v(carry0[225])
.save v(carry0[224])
.save v(carry0[223])
.save v(carry0[222])
.save v(carry0[221])
.save v(carry0[220])
.save v(carry0[219])
.save v(carry0[218])
.save v(carry0[217])
.save v(carry0[216])
.save v(carry0[215])
.save v(carry0[214])
.save v(carry0[213])
.save v(carry0[212])
.save v(carry0[211])
.save v(carry0[210])
.save v(carry0[209])
.save v(carry0[208])
.save v(carry0[207])
.save v(carry0[206])
.save v(carry0[205])
.save v(carry0[204])
.save v(carry0[203])
.save v(carry0[202])
.save v(carry0[201])
.save v(carry0[200])
.save v(carry0[199])
.save v(carry0[198])
.save v(carry0[197])
.save v(carry0[196])
.save v(carry0[195])
.save v(carry0[194])
.save v(carry0[193])
.save v(carry0[192])
.save v(carry0[191])
.save v(carry0[190])
.save v(carry0[189])
.save v(carry0[188])
.save v(carry0[187])
.save v(carry0[186])
.save v(carry0[185])
.save v(carry0[184])
.save v(carry0[183])
.save v(carry0[182])
.save v(carry0[181])
.save v(carry0[180])
.save v(carry0[179])
.save v(carry0[178])
.save v(carry0[177])
.save v(carry0[176])
.save v(carry0[175])
.save v(carry0[174])
.save v(carry0[173])
.save v(carry0[172])
.save v(carry0[171])
.save v(carry0[170])
.save v(carry0[169])
.save v(carry0[168])
.save v(carry0[167])
.save v(carry0[166])
.save v(carry0[165])
.save v(carry0[164])
.save v(carry0[163])
.save v(carry0[162])
.save v(carry0[161])
.save v(carry0[160])
.save v(carry0[159])
.save v(carry0[158])
.save v(carry0[157])
.save v(carry0[156])
.save v(carry0[155])
.save v(carry0[154])
.save v(carry0[153])
.save v(carry0[152])
.save v(carry0[151])
.save v(carry0[150])
.save v(carry0[149])
.save v(carry0[148])
.save v(carry0[147])
.save v(carry0[146])
.save v(carry0[145])
.save v(carry0[144])
.save v(carry0[143])
.save v(carry0[142])
.save v(carry0[141])
.save v(carry0[140])
.save v(carry0[139])
.save v(carry0[138])
.save v(carry0[137])
.save v(carry0[136])
.save v(carry0[135])
.save v(carry0[134])
.save v(carry0[133])
.save v(carry0[132])
.save v(carry0[131])
.save v(carry0[130])
.save v(carry0[129])
.save v(carry0[128])
.save v(carry0[127])
.save v(carry0[126])
.save v(carry0[125])
.save v(carry0[124])
.save v(carry0[123])
.save v(carry0[122])
.save v(carry0[121])
.save v(carry0[120])
.save v(carry0[119])
.save v(carry0[118])
.save v(carry0[117])
.save v(carry0[116])
.save v(carry0[115])
.save v(carry0[114])
.save v(carry0[113])
.save v(carry0[112])
.save v(carry0[111])
.save v(carry0[110])
.save v(carry0[109])
.save v(carry0[108])
.save v(carry0[107])
.save v(carry0[106])
.save v(carry0[105])
.save v(carry0[104])
.save v(carry0[103])
.save v(carry0[102])
.save v(carry0[101])
.save v(carry0[100])
.save v(carry0[99])
.save v(carry0[98])
.save v(carry0[97])
.save v(carry0[96])
.save v(carry0[95])
.save v(carry0[94])
.save v(carry0[93])
.save v(carry0[92])
.save v(carry0[91])
.save v(carry0[90])
.save v(carry0[89])
.save v(carry0[88])
.save v(carry0[87])
.save v(carry0[86])
.save v(carry0[85])
.save v(carry0[84])
.save v(carry0[83])
.save v(carry0[82])
.save v(carry0[81])
.save v(carry0[80])
.save v(carry0[79])
.save v(carry0[78])
.save v(carry0[77])
.save v(carry0[76])
.save v(carry0[75])
.save v(carry0[74])
.save v(carry0[73])
.save v(carry0[72])
.save v(carry0[71])
.save v(carry0[70])
.save v(carry0[69])
.save v(carry0[68])
.save v(carry0[67])
.save v(carry0[66])
.save v(carry0[65])
.save v(carry0[64])
.save v(carry0[63])
.save v(carry0[62])
.save v(carry0[61])
.save v(carry0[60])
.save v(carry0[59])
.save v(carry0[58])
.save v(carry0[57])
.save v(carry0[56])
.save v(carry0[55])
.save v(carry0[54])
.save v(carry0[53])
.save v(carry0[52])
.save v(carry0[51])
.save v(carry0[50])
.save v(carry0[49])
.save v(carry0[48])
.save v(carry0[47])
.save v(carry0[46])
.save v(carry0[45])
.save v(carry0[44])
.save v(carry0[43])
.save v(carry0[42])
.save v(carry0[41])
.save v(carry0[40])
.save v(carry0[39])
.save v(carry0[38])
.save v(carry0[37])
.save v(carry0[36])
.save v(carry0[35])
.save v(carry0[34])
.save v(carry0[33])
.save v(carry0[32])
.save v(carry0[31])
.save v(carry0[30])
.save v(carry0[29])
.save v(carry0[28])
.save v(carry0[27])
.save v(carry0[26])
.save v(carry0[25])
.save v(carry0[24])
.save v(carry0[23])
.save v(carry0[22])
.save v(carry0[21])
.save v(carry0[20])
.save v(carry0[19])
.save v(carry0[18])
.save v(carry0[17])
.save v(carry0[16])
.save v(carry0[15])
.save v(carry0[14])
.save v(carry0[13])
.save v(carry0[12])
.save v(carry0[11])
.save v(carry0[10])
.save v(carry0[9])
.save v(carry0[8])
.save v(carry0[7])
.save v(carry0[6])
.save v(carry0[5])
.save v(carry0[4])
.save v(carry0[3])
.save v(carry0[2])
.save v(carry0[1])
.save v(carry0[0])
.save v(s0[255])
.save v(s0[254])
.save v(s0[253])
.save v(s0[252])
.save v(s0[251])
.save v(s0[250])
.save v(s0[249])
.save v(s0[248])
.save v(s0[247])
.save v(s0[246])
.save v(s0[245])
.save v(s0[244])
.save v(s0[243])
.save v(s0[242])
.save v(s0[241])
.save v(s0[240])
.save v(s0[239])
.save v(s0[238])
.save v(s0[237])
.save v(s0[236])
.save v(s0[235])
.save v(s0[234])
.save v(s0[233])
.save v(s0[232])
.save v(s0[231])
.save v(s0[230])
.save v(s0[229])
.save v(s0[228])
.save v(s0[227])
.save v(s0[226])
.save v(s0[225])
.save v(s0[224])
.save v(s0[223])
.save v(s0[222])
.save v(s0[221])
.save v(s0[220])
.save v(s0[219])
.save v(s0[218])
.save v(s0[217])
.save v(s0[216])
.save v(s0[215])
.save v(s0[214])
.save v(s0[213])
.save v(s0[212])
.save v(s0[211])
.save v(s0[210])
.save v(s0[209])
.save v(s0[208])
.save v(s0[207])
.save v(s0[206])
.save v(s0[205])
.save v(s0[204])
.save v(s0[203])
.save v(s0[202])
.save v(s0[201])
.save v(s0[200])
.save v(s0[199])
.save v(s0[198])
.save v(s0[197])
.save v(s0[196])
.save v(s0[195])
.save v(s0[194])
.save v(s0[193])
.save v(s0[192])
.save v(s0[191])
.save v(s0[190])
.save v(s0[189])
.save v(s0[188])
.save v(s0[187])
.save v(s0[186])
.save v(s0[185])
.save v(s0[184])
.save v(s0[183])
.save v(s0[182])
.save v(s0[181])
.save v(s0[180])
.save v(s0[179])
.save v(s0[178])
.save v(s0[177])
.save v(s0[176])
.save v(s0[175])
.save v(s0[174])
.save v(s0[173])
.save v(s0[172])
.save v(s0[171])
.save v(s0[170])
.save v(s0[169])
.save v(s0[168])
.save v(s0[167])
.save v(s0[166])
.save v(s0[165])
.save v(s0[164])
.save v(s0[163])
.save v(s0[162])
.save v(s0[161])
.save v(s0[160])
.save v(s0[159])
.save v(s0[158])
.save v(s0[157])
.save v(s0[156])
.save v(s0[155])
.save v(s0[154])
.save v(s0[153])
.save v(s0[152])
.save v(s0[151])
.save v(s0[150])
.save v(s0[149])
.save v(s0[148])
.save v(s0[147])
.save v(s0[146])
.save v(s0[145])
.save v(s0[144])
.save v(s0[143])
.save v(s0[142])
.save v(s0[141])
.save v(s0[140])
.save v(s0[139])
.save v(s0[138])
.save v(s0[137])
.save v(s0[136])
.save v(s0[135])
.save v(s0[134])
.save v(s0[133])
.save v(s0[132])
.save v(s0[131])
.save v(s0[130])
.save v(s0[129])
.save v(s0[128])
.save v(s0[127])
.save v(s0[126])
.save v(s0[125])
.save v(s0[124])
.save v(s0[123])
.save v(s0[122])
.save v(s0[121])
.save v(s0[120])
.save v(s0[119])
.save v(s0[118])
.save v(s0[117])
.save v(s0[116])
.save v(s0[115])
.save v(s0[114])
.save v(s0[113])
.save v(s0[112])
.save v(s0[111])
.save v(s0[110])
.save v(s0[109])
.save v(s0[108])
.save v(s0[107])
.save v(s0[106])
.save v(s0[105])
.save v(s0[104])
.save v(s0[103])
.save v(s0[102])
.save v(s0[101])
.save v(s0[100])
.save v(s0[99])
.save v(s0[98])
.save v(s0[97])
.save v(s0[96])
.save v(s0[95])
.save v(s0[94])
.save v(s0[93])
.save v(s0[92])
.save v(s0[91])
.save v(s0[90])
.save v(s0[89])
.save v(s0[88])
.save v(s0[87])
.save v(s0[86])
.save v(s0[85])
.save v(s0[84])
.save v(s0[83])
.save v(s0[82])
.save v(s0[81])
.save v(s0[80])
.save v(s0[79])
.save v(s0[78])
.save v(s0[77])
.save v(s0[76])
.save v(s0[75])
.save v(s0[74])
.save v(s0[73])
.save v(s0[72])
.save v(s0[71])
.save v(s0[70])
.save v(s0[69])
.save v(s0[68])
.save v(s0[67])
.save v(s0[66])
.save v(s0[65])
.save v(s0[64])
.save v(s0[63])
.save v(s0[62])
.save v(s0[61])
.save v(s0[60])
.save v(s0[59])
.save v(s0[58])
.save v(s0[57])
.save v(s0[56])
.save v(s0[55])
.save v(s0[54])
.save v(s0[53])
.save v(s0[52])
.save v(s0[51])
.save v(s0[50])
.save v(s0[49])
.save v(s0[48])
.save v(s0[47])
.save v(s0[46])
.save v(s0[45])
.save v(s0[44])
.save v(s0[43])
.save v(s0[42])
.save v(s0[41])
.save v(s0[40])
.save v(s0[39])
.save v(s0[38])
.save v(s0[37])
.save v(s0[36])
.save v(s0[35])
.save v(s0[34])
.save v(s0[33])
.save v(s0[32])
.save v(s0[31])
.save v(s0[30])
.save v(s0[29])
.save v(s0[28])
.save v(s0[27])
.save v(s0[26])
.save v(s0[25])
.save v(s0[24])
.save v(s0[23])
.save v(s0[22])
.save v(s0[21])
.save v(s0[20])
.save v(s0[19])
.save v(s0[18])
.save v(s0[17])
.save v(s0[16])
.save v(s0[15])
.save v(s0[14])
.save v(s0[13])
.save v(s0[12])
.save v(s0[11])
.save v(s0[10])
.save v(s0[9])
.save v(s0[8])
.save v(s0[7])
.save v(s0[6])
.save v(s0[5])
.save v(s0[4])
.save v(s0[3])
.save v(s0[2])
.save v(s0[1])
.save v(s0[0])
.save v(vcc)
C7[255] S0[255] 0 5f m=1
C7[254] S0[254] 0 5f m=1
C7[253] S0[253] 0 5f m=1
C7[252] S0[252] 0 5f m=1
C7[251] S0[251] 0 5f m=1
C7[250] S0[250] 0 5f m=1
C7[249] S0[249] 0 5f m=1
C7[248] S0[248] 0 5f m=1
C7[247] S0[247] 0 5f m=1
C7[246] S0[246] 0 5f m=1
C7[245] S0[245] 0 5f m=1
C7[244] S0[244] 0 5f m=1
C7[243] S0[243] 0 5f m=1
C7[242] S0[242] 0 5f m=1
C7[241] S0[241] 0 5f m=1
C7[240] S0[240] 0 5f m=1
C7[239] S0[239] 0 5f m=1
C7[238] S0[238] 0 5f m=1
C7[237] S0[237] 0 5f m=1
C7[236] S0[236] 0 5f m=1
C7[235] S0[235] 0 5f m=1
C7[234] S0[234] 0 5f m=1
C7[233] S0[233] 0 5f m=1
C7[232] S0[232] 0 5f m=1
C7[231] S0[231] 0 5f m=1
C7[230] S0[230] 0 5f m=1
C7[229] S0[229] 0 5f m=1
C7[228] S0[228] 0 5f m=1
C7[227] S0[227] 0 5f m=1
C7[226] S0[226] 0 5f m=1
C7[225] S0[225] 0 5f m=1
C7[224] S0[224] 0 5f m=1
C7[223] S0[223] 0 5f m=1
C7[222] S0[222] 0 5f m=1
C7[221] S0[221] 0 5f m=1
C7[220] S0[220] 0 5f m=1
C7[219] S0[219] 0 5f m=1
C7[218] S0[218] 0 5f m=1
C7[217] S0[217] 0 5f m=1
C7[216] S0[216] 0 5f m=1
C7[215] S0[215] 0 5f m=1
C7[214] S0[214] 0 5f m=1
C7[213] S0[213] 0 5f m=1
C7[212] S0[212] 0 5f m=1
C7[211] S0[211] 0 5f m=1
C7[210] S0[210] 0 5f m=1
C7[209] S0[209] 0 5f m=1
C7[208] S0[208] 0 5f m=1
C7[207] S0[207] 0 5f m=1
C7[206] S0[206] 0 5f m=1
C7[205] S0[205] 0 5f m=1
C7[204] S0[204] 0 5f m=1
C7[203] S0[203] 0 5f m=1
C7[202] S0[202] 0 5f m=1
C7[201] S0[201] 0 5f m=1
C7[200] S0[200] 0 5f m=1
C7[199] S0[199] 0 5f m=1
C7[198] S0[198] 0 5f m=1
C7[197] S0[197] 0 5f m=1
C7[196] S0[196] 0 5f m=1
C7[195] S0[195] 0 5f m=1
C7[194] S0[194] 0 5f m=1
C7[193] S0[193] 0 5f m=1
C7[192] S0[192] 0 5f m=1
C7[191] S0[191] 0 5f m=1
C7[190] S0[190] 0 5f m=1
C7[189] S0[189] 0 5f m=1
C7[188] S0[188] 0 5f m=1
C7[187] S0[187] 0 5f m=1
C7[186] S0[186] 0 5f m=1
C7[185] S0[185] 0 5f m=1
C7[184] S0[184] 0 5f m=1
C7[183] S0[183] 0 5f m=1
C7[182] S0[182] 0 5f m=1
C7[181] S0[181] 0 5f m=1
C7[180] S0[180] 0 5f m=1
C7[179] S0[179] 0 5f m=1
C7[178] S0[178] 0 5f m=1
C7[177] S0[177] 0 5f m=1
C7[176] S0[176] 0 5f m=1
C7[175] S0[175] 0 5f m=1
C7[174] S0[174] 0 5f m=1
C7[173] S0[173] 0 5f m=1
C7[172] S0[172] 0 5f m=1
C7[171] S0[171] 0 5f m=1
C7[170] S0[170] 0 5f m=1
C7[169] S0[169] 0 5f m=1
C7[168] S0[168] 0 5f m=1
C7[167] S0[167] 0 5f m=1
C7[166] S0[166] 0 5f m=1
C7[165] S0[165] 0 5f m=1
C7[164] S0[164] 0 5f m=1
C7[163] S0[163] 0 5f m=1
C7[162] S0[162] 0 5f m=1
C7[161] S0[161] 0 5f m=1
C7[160] S0[160] 0 5f m=1
C7[159] S0[159] 0 5f m=1
C7[158] S0[158] 0 5f m=1
C7[157] S0[157] 0 5f m=1
C7[156] S0[156] 0 5f m=1
C7[155] S0[155] 0 5f m=1
C7[154] S0[154] 0 5f m=1
C7[153] S0[153] 0 5f m=1
C7[152] S0[152] 0 5f m=1
C7[151] S0[151] 0 5f m=1
C7[150] S0[150] 0 5f m=1
C7[149] S0[149] 0 5f m=1
C7[148] S0[148] 0 5f m=1
C7[147] S0[147] 0 5f m=1
C7[146] S0[146] 0 5f m=1
C7[145] S0[145] 0 5f m=1
C7[144] S0[144] 0 5f m=1
C7[143] S0[143] 0 5f m=1
C7[142] S0[142] 0 5f m=1
C7[141] S0[141] 0 5f m=1
C7[140] S0[140] 0 5f m=1
C7[139] S0[139] 0 5f m=1
C7[138] S0[138] 0 5f m=1
C7[137] S0[137] 0 5f m=1
C7[136] S0[136] 0 5f m=1
C7[135] S0[135] 0 5f m=1
C7[134] S0[134] 0 5f m=1
C7[133] S0[133] 0 5f m=1
C7[132] S0[132] 0 5f m=1
C7[131] S0[131] 0 5f m=1
C7[130] S0[130] 0 5f m=1
C7[129] S0[129] 0 5f m=1
C7[128] S0[128] 0 5f m=1
C7[127] S0[127] 0 5f m=1
C7[126] S0[126] 0 5f m=1
C7[125] S0[125] 0 5f m=1
C7[124] S0[124] 0 5f m=1
C7[123] S0[123] 0 5f m=1
C7[122] S0[122] 0 5f m=1
C7[121] S0[121] 0 5f m=1
C7[120] S0[120] 0 5f m=1
C7[119] S0[119] 0 5f m=1
C7[118] S0[118] 0 5f m=1
C7[117] S0[117] 0 5f m=1
C7[116] S0[116] 0 5f m=1
C7[115] S0[115] 0 5f m=1
C7[114] S0[114] 0 5f m=1
C7[113] S0[113] 0 5f m=1
C7[112] S0[112] 0 5f m=1
C7[111] S0[111] 0 5f m=1
C7[110] S0[110] 0 5f m=1
C7[109] S0[109] 0 5f m=1
C7[108] S0[108] 0 5f m=1
C7[107] S0[107] 0 5f m=1
C7[106] S0[106] 0 5f m=1
C7[105] S0[105] 0 5f m=1
C7[104] S0[104] 0 5f m=1
C7[103] S0[103] 0 5f m=1
C7[102] S0[102] 0 5f m=1
C7[101] S0[101] 0 5f m=1
C7[100] S0[100] 0 5f m=1
C7[99] S0[99] 0 5f m=1
C7[98] S0[98] 0 5f m=1
C7[97] S0[97] 0 5f m=1
C7[96] S0[96] 0 5f m=1
C7[95] S0[95] 0 5f m=1
C7[94] S0[94] 0 5f m=1
C7[93] S0[93] 0 5f m=1
C7[92] S0[92] 0 5f m=1
C7[91] S0[91] 0 5f m=1
C7[90] S0[90] 0 5f m=1
C7[89] S0[89] 0 5f m=1
C7[88] S0[88] 0 5f m=1
C7[87] S0[87] 0 5f m=1
C7[86] S0[86] 0 5f m=1
C7[85] S0[85] 0 5f m=1
C7[84] S0[84] 0 5f m=1
C7[83] S0[83] 0 5f m=1
C7[82] S0[82] 0 5f m=1
C7[81] S0[81] 0 5f m=1
C7[80] S0[80] 0 5f m=1
C7[79] S0[79] 0 5f m=1
C7[78] S0[78] 0 5f m=1
C7[77] S0[77] 0 5f m=1
C7[76] S0[76] 0 5f m=1
C7[75] S0[75] 0 5f m=1
C7[74] S0[74] 0 5f m=1
C7[73] S0[73] 0 5f m=1
C7[72] S0[72] 0 5f m=1
C7[71] S0[71] 0 5f m=1
C7[70] S0[70] 0 5f m=1
C7[69] S0[69] 0 5f m=1
C7[68] S0[68] 0 5f m=1
C7[67] S0[67] 0 5f m=1
C7[66] S0[66] 0 5f m=1
C7[65] S0[65] 0 5f m=1
C7[64] S0[64] 0 5f m=1
C7[63] S0[63] 0 5f m=1
C7[62] S0[62] 0 5f m=1
C7[61] S0[61] 0 5f m=1
C7[60] S0[60] 0 5f m=1
C7[59] S0[59] 0 5f m=1
C7[58] S0[58] 0 5f m=1
C7[57] S0[57] 0 5f m=1
C7[56] S0[56] 0 5f m=1
C7[55] S0[55] 0 5f m=1
C7[54] S0[54] 0 5f m=1
C7[53] S0[53] 0 5f m=1
C7[52] S0[52] 0 5f m=1
C7[51] S0[51] 0 5f m=1
C7[50] S0[50] 0 5f m=1
C7[49] S0[49] 0 5f m=1
C7[48] S0[48] 0 5f m=1
C7[47] S0[47] 0 5f m=1
C7[46] S0[46] 0 5f m=1
C7[45] S0[45] 0 5f m=1
C7[44] S0[44] 0 5f m=1
C7[43] S0[43] 0 5f m=1
C7[42] S0[42] 0 5f m=1
C7[41] S0[41] 0 5f m=1
C7[40] S0[40] 0 5f m=1
C7[39] S0[39] 0 5f m=1
C7[38] S0[38] 0 5f m=1
C7[37] S0[37] 0 5f m=1
C7[36] S0[36] 0 5f m=1
C7[35] S0[35] 0 5f m=1
C7[34] S0[34] 0 5f m=1
C7[33] S0[33] 0 5f m=1
C7[32] S0[32] 0 5f m=1
C7[31] S0[31] 0 5f m=1
C7[30] S0[30] 0 5f m=1
C7[29] S0[29] 0 5f m=1
C7[28] S0[28] 0 5f m=1
C7[27] S0[27] 0 5f m=1
C7[26] S0[26] 0 5f m=1
C7[25] S0[25] 0 5f m=1
C7[24] S0[24] 0 5f m=1
C7[23] S0[23] 0 5f m=1
C7[22] S0[22] 0 5f m=1
C7[21] S0[21] 0 5f m=1
C7[20] S0[20] 0 5f m=1
C7[19] S0[19] 0 5f m=1
C7[18] S0[18] 0 5f m=1
C7[17] S0[17] 0 5f m=1
C7[16] S0[16] 0 5f m=1
C7[15] S0[15] 0 5f m=1
C7[14] S0[14] 0 5f m=1
C7[13] S0[13] 0 5f m=1
C7[12] S0[12] 0 5f m=1
C7[11] S0[11] 0 5f m=1
C7[10] S0[10] 0 5f m=1
C7[9] S0[9] 0 5f m=1
C7[8] S0[8] 0 5f m=1
C7[7] S0[7] 0 5f m=1
C7[6] S0[6] 0 5f m=1
C7[5] S0[5] 0 5f m=1
C7[4] S0[4] 0 5f m=1
C7[3] S0[3] 0 5f m=1
C7[2] S0[2] 0 5f m=1
C7[1] S0[1] 0 5f m=1
C7[0] S0[0] 0 5f m=1
C8[255] CARRY0[255] 0 5f m=1
C8[254] CARRY0[254] 0 5f m=1
C8[253] CARRY0[253] 0 5f m=1
C8[252] CARRY0[252] 0 5f m=1
C8[251] CARRY0[251] 0 5f m=1
C8[250] CARRY0[250] 0 5f m=1
C8[249] CARRY0[249] 0 5f m=1
C8[248] CARRY0[248] 0 5f m=1
C8[247] CARRY0[247] 0 5f m=1
C8[246] CARRY0[246] 0 5f m=1
C8[245] CARRY0[245] 0 5f m=1
C8[244] CARRY0[244] 0 5f m=1
C8[243] CARRY0[243] 0 5f m=1
C8[242] CARRY0[242] 0 5f m=1
C8[241] CARRY0[241] 0 5f m=1
C8[240] CARRY0[240] 0 5f m=1
C8[239] CARRY0[239] 0 5f m=1
C8[238] CARRY0[238] 0 5f m=1
C8[237] CARRY0[237] 0 5f m=1
C8[236] CARRY0[236] 0 5f m=1
C8[235] CARRY0[235] 0 5f m=1
C8[234] CARRY0[234] 0 5f m=1
C8[233] CARRY0[233] 0 5f m=1
C8[232] CARRY0[232] 0 5f m=1
C8[231] CARRY0[231] 0 5f m=1
C8[230] CARRY0[230] 0 5f m=1
C8[229] CARRY0[229] 0 5f m=1
C8[228] CARRY0[228] 0 5f m=1
C8[227] CARRY0[227] 0 5f m=1
C8[226] CARRY0[226] 0 5f m=1
C8[225] CARRY0[225] 0 5f m=1
C8[224] CARRY0[224] 0 5f m=1
C8[223] CARRY0[223] 0 5f m=1
C8[222] CARRY0[222] 0 5f m=1
C8[221] CARRY0[221] 0 5f m=1
C8[220] CARRY0[220] 0 5f m=1
C8[219] CARRY0[219] 0 5f m=1
C8[218] CARRY0[218] 0 5f m=1
C8[217] CARRY0[217] 0 5f m=1
C8[216] CARRY0[216] 0 5f m=1
C8[215] CARRY0[215] 0 5f m=1
C8[214] CARRY0[214] 0 5f m=1
C8[213] CARRY0[213] 0 5f m=1
C8[212] CARRY0[212] 0 5f m=1
C8[211] CARRY0[211] 0 5f m=1
C8[210] CARRY0[210] 0 5f m=1
C8[209] CARRY0[209] 0 5f m=1
C8[208] CARRY0[208] 0 5f m=1
C8[207] CARRY0[207] 0 5f m=1
C8[206] CARRY0[206] 0 5f m=1
C8[205] CARRY0[205] 0 5f m=1
C8[204] CARRY0[204] 0 5f m=1
C8[203] CARRY0[203] 0 5f m=1
C8[202] CARRY0[202] 0 5f m=1
C8[201] CARRY0[201] 0 5f m=1
C8[200] CARRY0[200] 0 5f m=1
C8[199] CARRY0[199] 0 5f m=1
C8[198] CARRY0[198] 0 5f m=1
C8[197] CARRY0[197] 0 5f m=1
C8[196] CARRY0[196] 0 5f m=1
C8[195] CARRY0[195] 0 5f m=1
C8[194] CARRY0[194] 0 5f m=1
C8[193] CARRY0[193] 0 5f m=1
C8[192] CARRY0[192] 0 5f m=1
C8[191] CARRY0[191] 0 5f m=1
C8[190] CARRY0[190] 0 5f m=1
C8[189] CARRY0[189] 0 5f m=1
C8[188] CARRY0[188] 0 5f m=1
C8[187] CARRY0[187] 0 5f m=1
C8[186] CARRY0[186] 0 5f m=1
C8[185] CARRY0[185] 0 5f m=1
C8[184] CARRY0[184] 0 5f m=1
C8[183] CARRY0[183] 0 5f m=1
C8[182] CARRY0[182] 0 5f m=1
C8[181] CARRY0[181] 0 5f m=1
C8[180] CARRY0[180] 0 5f m=1
C8[179] CARRY0[179] 0 5f m=1
C8[178] CARRY0[178] 0 5f m=1
C8[177] CARRY0[177] 0 5f m=1
C8[176] CARRY0[176] 0 5f m=1
C8[175] CARRY0[175] 0 5f m=1
C8[174] CARRY0[174] 0 5f m=1
C8[173] CARRY0[173] 0 5f m=1
C8[172] CARRY0[172] 0 5f m=1
C8[171] CARRY0[171] 0 5f m=1
C8[170] CARRY0[170] 0 5f m=1
C8[169] CARRY0[169] 0 5f m=1
C8[168] CARRY0[168] 0 5f m=1
C8[167] CARRY0[167] 0 5f m=1
C8[166] CARRY0[166] 0 5f m=1
C8[165] CARRY0[165] 0 5f m=1
C8[164] CARRY0[164] 0 5f m=1
C8[163] CARRY0[163] 0 5f m=1
C8[162] CARRY0[162] 0 5f m=1
C8[161] CARRY0[161] 0 5f m=1
C8[160] CARRY0[160] 0 5f m=1
C8[159] CARRY0[159] 0 5f m=1
C8[158] CARRY0[158] 0 5f m=1
C8[157] CARRY0[157] 0 5f m=1
C8[156] CARRY0[156] 0 5f m=1
C8[155] CARRY0[155] 0 5f m=1
C8[154] CARRY0[154] 0 5f m=1
C8[153] CARRY0[153] 0 5f m=1
C8[152] CARRY0[152] 0 5f m=1
C8[151] CARRY0[151] 0 5f m=1
C8[150] CARRY0[150] 0 5f m=1
C8[149] CARRY0[149] 0 5f m=1
C8[148] CARRY0[148] 0 5f m=1
C8[147] CARRY0[147] 0 5f m=1
C8[146] CARRY0[146] 0 5f m=1
C8[145] CARRY0[145] 0 5f m=1
C8[144] CARRY0[144] 0 5f m=1
C8[143] CARRY0[143] 0 5f m=1
C8[142] CARRY0[142] 0 5f m=1
C8[141] CARRY0[141] 0 5f m=1
C8[140] CARRY0[140] 0 5f m=1
C8[139] CARRY0[139] 0 5f m=1
C8[138] CARRY0[138] 0 5f m=1
C8[137] CARRY0[137] 0 5f m=1
C8[136] CARRY0[136] 0 5f m=1
C8[135] CARRY0[135] 0 5f m=1
C8[134] CARRY0[134] 0 5f m=1
C8[133] CARRY0[133] 0 5f m=1
C8[132] CARRY0[132] 0 5f m=1
C8[131] CARRY0[131] 0 5f m=1
C8[130] CARRY0[130] 0 5f m=1
C8[129] CARRY0[129] 0 5f m=1
C8[128] CARRY0[128] 0 5f m=1
C8[127] CARRY0[127] 0 5f m=1
C8[126] CARRY0[126] 0 5f m=1
C8[125] CARRY0[125] 0 5f m=1
C8[124] CARRY0[124] 0 5f m=1
C8[123] CARRY0[123] 0 5f m=1
C8[122] CARRY0[122] 0 5f m=1
C8[121] CARRY0[121] 0 5f m=1
C8[120] CARRY0[120] 0 5f m=1
C8[119] CARRY0[119] 0 5f m=1
C8[118] CARRY0[118] 0 5f m=1
C8[117] CARRY0[117] 0 5f m=1
C8[116] CARRY0[116] 0 5f m=1
C8[115] CARRY0[115] 0 5f m=1
C8[114] CARRY0[114] 0 5f m=1
C8[113] CARRY0[113] 0 5f m=1
C8[112] CARRY0[112] 0 5f m=1
C8[111] CARRY0[111] 0 5f m=1
C8[110] CARRY0[110] 0 5f m=1
C8[109] CARRY0[109] 0 5f m=1
C8[108] CARRY0[108] 0 5f m=1
C8[107] CARRY0[107] 0 5f m=1
C8[106] CARRY0[106] 0 5f m=1
C8[105] CARRY0[105] 0 5f m=1
C8[104] CARRY0[104] 0 5f m=1
C8[103] CARRY0[103] 0 5f m=1
C8[102] CARRY0[102] 0 5f m=1
C8[101] CARRY0[101] 0 5f m=1
C8[100] CARRY0[100] 0 5f m=1
C8[99] CARRY0[99] 0 5f m=1
C8[98] CARRY0[98] 0 5f m=1
C8[97] CARRY0[97] 0 5f m=1
C8[96] CARRY0[96] 0 5f m=1
C8[95] CARRY0[95] 0 5f m=1
C8[94] CARRY0[94] 0 5f m=1
C8[93] CARRY0[93] 0 5f m=1
C8[92] CARRY0[92] 0 5f m=1
C8[91] CARRY0[91] 0 5f m=1
C8[90] CARRY0[90] 0 5f m=1
C8[89] CARRY0[89] 0 5f m=1
C8[88] CARRY0[88] 0 5f m=1
C8[87] CARRY0[87] 0 5f m=1
C8[86] CARRY0[86] 0 5f m=1
C8[85] CARRY0[85] 0 5f m=1
C8[84] CARRY0[84] 0 5f m=1
C8[83] CARRY0[83] 0 5f m=1
C8[82] CARRY0[82] 0 5f m=1
C8[81] CARRY0[81] 0 5f m=1
C8[80] CARRY0[80] 0 5f m=1
C8[79] CARRY0[79] 0 5f m=1
C8[78] CARRY0[78] 0 5f m=1
C8[77] CARRY0[77] 0 5f m=1
C8[76] CARRY0[76] 0 5f m=1
C8[75] CARRY0[75] 0 5f m=1
C8[74] CARRY0[74] 0 5f m=1
C8[73] CARRY0[73] 0 5f m=1
C8[72] CARRY0[72] 0 5f m=1
C8[71] CARRY0[71] 0 5f m=1
C8[70] CARRY0[70] 0 5f m=1
C8[69] CARRY0[69] 0 5f m=1
C8[68] CARRY0[68] 0 5f m=1
C8[67] CARRY0[67] 0 5f m=1
C8[66] CARRY0[66] 0 5f m=1
C8[65] CARRY0[65] 0 5f m=1
C8[64] CARRY0[64] 0 5f m=1
C8[63] CARRY0[63] 0 5f m=1
C8[62] CARRY0[62] 0 5f m=1
C8[61] CARRY0[61] 0 5f m=1
C8[60] CARRY0[60] 0 5f m=1
C8[59] CARRY0[59] 0 5f m=1
C8[58] CARRY0[58] 0 5f m=1
C8[57] CARRY0[57] 0 5f m=1
C8[56] CARRY0[56] 0 5f m=1
C8[55] CARRY0[55] 0 5f m=1
C8[54] CARRY0[54] 0 5f m=1
C8[53] CARRY0[53] 0 5f m=1
C8[52] CARRY0[52] 0 5f m=1
C8[51] CARRY0[51] 0 5f m=1
C8[50] CARRY0[50] 0 5f m=1
C8[49] CARRY0[49] 0 5f m=1
C8[48] CARRY0[48] 0 5f m=1
C8[47] CARRY0[47] 0 5f m=1
C8[46] CARRY0[46] 0 5f m=1
C8[45] CARRY0[45] 0 5f m=1
C8[44] CARRY0[44] 0 5f m=1
C8[43] CARRY0[43] 0 5f m=1
C8[42] CARRY0[42] 0 5f m=1
C8[41] CARRY0[41] 0 5f m=1
C8[40] CARRY0[40] 0 5f m=1
C8[39] CARRY0[39] 0 5f m=1
C8[38] CARRY0[38] 0 5f m=1
C8[37] CARRY0[37] 0 5f m=1
C8[36] CARRY0[36] 0 5f m=1
C8[35] CARRY0[35] 0 5f m=1
C8[34] CARRY0[34] 0 5f m=1
C8[33] CARRY0[33] 0 5f m=1
C8[32] CARRY0[32] 0 5f m=1
C8[31] CARRY0[31] 0 5f m=1
C8[30] CARRY0[30] 0 5f m=1
C8[29] CARRY0[29] 0 5f m=1
C8[28] CARRY0[28] 0 5f m=1
C8[27] CARRY0[27] 0 5f m=1
C8[26] CARRY0[26] 0 5f m=1
C8[25] CARRY0[25] 0 5f m=1
C8[24] CARRY0[24] 0 5f m=1
C8[23] CARRY0[23] 0 5f m=1
C8[22] CARRY0[22] 0 5f m=1
C8[21] CARRY0[21] 0 5f m=1
C8[20] CARRY0[20] 0 5f m=1
C8[19] CARRY0[19] 0 5f m=1
C8[18] CARRY0[18] 0 5f m=1
C8[17] CARRY0[17] 0 5f m=1
C8[16] CARRY0[16] 0 5f m=1
C8[15] CARRY0[15] 0 5f m=1
C8[14] CARRY0[14] 0 5f m=1
C8[13] CARRY0[13] 0 5f m=1
C8[12] CARRY0[12] 0 5f m=1
C8[11] CARRY0[11] 0 5f m=1
C8[10] CARRY0[10] 0 5f m=1
C8[9] CARRY0[9] 0 5f m=1
C8[8] CARRY0[8] 0 5f m=1
C8[7] CARRY0[7] 0 5f m=1
C8[6] CARRY0[6] 0 5f m=1
C8[5] CARRY0[5] 0 5f m=1
C8[4] CARRY0[4] 0 5f m=1
C8[3] CARRY0[3] 0 5f m=1
C8[2] CARRY0[2] 0 5f m=1
C8[1] CARRY0[1] 0 5f m=1
C8[0] CARRY0[0] 0 5f m=1
x0 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16]
+ A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] S2[31] S2[30]
+ S2[29] S2[28] S2[27] S2[26] S2[25] S2[24] S2[23] S2[22] S2[21] S2[20] S2[19] S2[18] S2[17] S2[16] S2[15]
+ S2[14] S2[13] S2[12] S2[11] S2[10] S2[9] S2[8] S2[7] S2[6] S2[5] S2[4] S2[3] S2[2] S2[1] S2[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13]
+ B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] COUT2 SG2 CIN SP2 adder_32bit
.save v(cout2)
x1[31] A[31] B[31] CARRY1[30] VSS VSS VCC VCC CARRY1[31] S1[31] sky130_fd_sc_hd__fah_1
x1[30] A[30] B[30] CARRY1[29] VSS VSS VCC VCC CARRY1[30] S1[30] sky130_fd_sc_hd__fah_1
x1[29] A[29] B[29] CARRY1[28] VSS VSS VCC VCC CARRY1[29] S1[29] sky130_fd_sc_hd__fah_1
x1[28] A[28] B[28] CARRY1[27] VSS VSS VCC VCC CARRY1[28] S1[28] sky130_fd_sc_hd__fah_1
x1[27] A[27] B[27] CARRY1[26] VSS VSS VCC VCC CARRY1[27] S1[27] sky130_fd_sc_hd__fah_1
x1[26] A[26] B[26] CARRY1[25] VSS VSS VCC VCC CARRY1[26] S1[26] sky130_fd_sc_hd__fah_1
x1[25] A[25] B[25] CARRY1[24] VSS VSS VCC VCC CARRY1[25] S1[25] sky130_fd_sc_hd__fah_1
x1[24] A[24] B[24] CARRY1[23] VSS VSS VCC VCC CARRY1[24] S1[24] sky130_fd_sc_hd__fah_1
x1[23] A[23] B[23] CARRY1[22] VSS VSS VCC VCC CARRY1[23] S1[23] sky130_fd_sc_hd__fah_1
x1[22] A[22] B[22] CARRY1[21] VSS VSS VCC VCC CARRY1[22] S1[22] sky130_fd_sc_hd__fah_1
x1[21] A[21] B[21] CARRY1[20] VSS VSS VCC VCC CARRY1[21] S1[21] sky130_fd_sc_hd__fah_1
x1[20] A[20] B[20] CARRY1[19] VSS VSS VCC VCC CARRY1[20] S1[20] sky130_fd_sc_hd__fah_1
x1[19] A[19] B[19] CARRY1[18] VSS VSS VCC VCC CARRY1[19] S1[19] sky130_fd_sc_hd__fah_1
x1[18] A[18] B[18] CARRY1[17] VSS VSS VCC VCC CARRY1[18] S1[18] sky130_fd_sc_hd__fah_1
x1[17] A[17] B[17] CARRY1[16] VSS VSS VCC VCC CARRY1[17] S1[17] sky130_fd_sc_hd__fah_1
x1[16] A[16] B[16] CARRY1[15] VSS VSS VCC VCC CARRY1[16] S1[16] sky130_fd_sc_hd__fah_1
x1[15] A[15] B[15] CARRY1[14] VSS VSS VCC VCC CARRY1[15] S1[15] sky130_fd_sc_hd__fah_1
x1[14] A[14] B[14] CARRY1[13] VSS VSS VCC VCC CARRY1[14] S1[14] sky130_fd_sc_hd__fah_1
x1[13] A[13] B[13] CARRY1[12] VSS VSS VCC VCC CARRY1[13] S1[13] sky130_fd_sc_hd__fah_1
x1[12] A[12] B[12] CARRY1[11] VSS VSS VCC VCC CARRY1[12] S1[12] sky130_fd_sc_hd__fah_1
x1[11] A[11] B[11] CARRY1[10] VSS VSS VCC VCC CARRY1[11] S1[11] sky130_fd_sc_hd__fah_1
x1[10] A[10] B[10] CARRY1[9] VSS VSS VCC VCC CARRY1[10] S1[10] sky130_fd_sc_hd__fah_1
x1[9] A[9] B[9] CARRY1[8] VSS VSS VCC VCC CARRY1[9] S1[9] sky130_fd_sc_hd__fah_1
x1[8] A[8] B[8] CARRY1[7] VSS VSS VCC VCC CARRY1[8] S1[8] sky130_fd_sc_hd__fah_1
x1[7] A[7] B[7] CARRY1[6] VSS VSS VCC VCC CARRY1[7] S1[7] sky130_fd_sc_hd__fah_1
x1[6] A[6] B[6] CARRY1[5] VSS VSS VCC VCC CARRY1[6] S1[6] sky130_fd_sc_hd__fah_1
x1[5] A[5] B[5] CARRY1[4] VSS VSS VCC VCC CARRY1[5] S1[5] sky130_fd_sc_hd__fah_1
x1[4] A[4] B[4] CARRY1[3] VSS VSS VCC VCC CARRY1[4] S1[4] sky130_fd_sc_hd__fah_1
x1[3] A[3] B[3] CARRY1[2] VSS VSS VCC VCC CARRY1[3] S1[3] sky130_fd_sc_hd__fah_1
x1[2] A[2] B[2] CARRY1[1] VSS VSS VCC VCC CARRY1[2] S1[2] sky130_fd_sc_hd__fah_1
x1[1] A[1] B[1] CARRY1[0] VSS VSS VCC VCC CARRY1[1] S1[1] sky130_fd_sc_hd__fah_1
x1[0] A[0] B[0] CIN VSS VSS VCC VCC CARRY1[0] S1[0] sky130_fd_sc_hd__fah_1
.save v(carry1[31])
.save v(carry1[30])
.save v(carry1[29])
.save v(carry1[28])
.save v(carry1[27])
.save v(carry1[26])
.save v(carry1[25])
.save v(carry1[24])
.save v(carry1[23])
.save v(carry1[22])
.save v(carry1[21])
.save v(carry1[20])
.save v(carry1[19])
.save v(carry1[18])
.save v(carry1[17])
.save v(carry1[16])
.save v(carry1[15])
.save v(carry1[14])
.save v(carry1[13])
.save v(carry1[12])
.save v(carry1[11])
.save v(carry1[10])
.save v(carry1[9])
.save v(carry1[8])
.save v(carry1[7])
.save v(carry1[6])
.save v(carry1[5])
.save v(carry1[4])
.save v(carry1[3])
.save v(carry1[2])
.save v(carry1[1])
.save v(carry1[0])
.save v(s1[31])
.save v(s1[30])
.save v(s1[29])
.save v(s1[28])
.save v(s1[27])
.save v(s1[26])
.save v(s1[25])
.save v(s1[24])
.save v(s1[23])
.save v(s1[22])
.save v(s1[21])
.save v(s1[20])
.save v(s1[19])
.save v(s1[18])
.save v(s1[17])
.save v(s1[16])
.save v(s1[15])
.save v(s1[14])
.save v(s1[13])
.save v(s1[12])
.save v(s1[11])
.save v(s1[10])
.save v(s1[9])
.save v(s1[8])
.save v(s1[7])
.save v(s1[6])
.save v(s1[5])
.save v(s1[4])
.save v(s1[3])
.save v(s1[2])
.save v(s1[1])
.save v(s1[0])
.save v(s2[31])
.save v(s2[30])
.save v(s2[29])
.save v(s2[28])
.save v(s2[27])
.save v(s2[26])
.save v(s2[25])
.save v(s2[24])
.save v(s2[23])
.save v(s2[22])
.save v(s2[21])
.save v(s2[20])
.save v(s2[19])
.save v(s2[18])
.save v(s2[17])
.save v(s2[16])
.save v(s2[15])
.save v(s2[14])
.save v(s2[13])
.save v(s2[12])
.save v(s2[11])
.save v(s2[10])
.save v(s2[9])
.save v(s2[8])
.save v(s2[7])
.save v(s2[6])
.save v(s2[5])
.save v(s2[4])
.save v(s2[3])
.save v(s2[2])
.save v(s2[1])
.save v(s2[0])
C2[255] S3[255] 0 5f m=1
C2[254] S3[254] 0 5f m=1
C2[253] S3[253] 0 5f m=1
C2[252] S3[252] 0 5f m=1
C2[251] S3[251] 0 5f m=1
C2[250] S3[250] 0 5f m=1
C2[249] S3[249] 0 5f m=1
C2[248] S3[248] 0 5f m=1
C2[247] S3[247] 0 5f m=1
C2[246] S3[246] 0 5f m=1
C2[245] S3[245] 0 5f m=1
C2[244] S3[244] 0 5f m=1
C2[243] S3[243] 0 5f m=1
C2[242] S3[242] 0 5f m=1
C2[241] S3[241] 0 5f m=1
C2[240] S3[240] 0 5f m=1
C2[239] S3[239] 0 5f m=1
C2[238] S3[238] 0 5f m=1
C2[237] S3[237] 0 5f m=1
C2[236] S3[236] 0 5f m=1
C2[235] S3[235] 0 5f m=1
C2[234] S3[234] 0 5f m=1
C2[233] S3[233] 0 5f m=1
C2[232] S3[232] 0 5f m=1
C2[231] S3[231] 0 5f m=1
C2[230] S3[230] 0 5f m=1
C2[229] S3[229] 0 5f m=1
C2[228] S3[228] 0 5f m=1
C2[227] S3[227] 0 5f m=1
C2[226] S3[226] 0 5f m=1
C2[225] S3[225] 0 5f m=1
C2[224] S3[224] 0 5f m=1
C2[223] S3[223] 0 5f m=1
C2[222] S3[222] 0 5f m=1
C2[221] S3[221] 0 5f m=1
C2[220] S3[220] 0 5f m=1
C2[219] S3[219] 0 5f m=1
C2[218] S3[218] 0 5f m=1
C2[217] S3[217] 0 5f m=1
C2[216] S3[216] 0 5f m=1
C2[215] S3[215] 0 5f m=1
C2[214] S3[214] 0 5f m=1
C2[213] S3[213] 0 5f m=1
C2[212] S3[212] 0 5f m=1
C2[211] S3[211] 0 5f m=1
C2[210] S3[210] 0 5f m=1
C2[209] S3[209] 0 5f m=1
C2[208] S3[208] 0 5f m=1
C2[207] S3[207] 0 5f m=1
C2[206] S3[206] 0 5f m=1
C2[205] S3[205] 0 5f m=1
C2[204] S3[204] 0 5f m=1
C2[203] S3[203] 0 5f m=1
C2[202] S3[202] 0 5f m=1
C2[201] S3[201] 0 5f m=1
C2[200] S3[200] 0 5f m=1
C2[199] S3[199] 0 5f m=1
C2[198] S3[198] 0 5f m=1
C2[197] S3[197] 0 5f m=1
C2[196] S3[196] 0 5f m=1
C2[195] S3[195] 0 5f m=1
C2[194] S3[194] 0 5f m=1
C2[193] S3[193] 0 5f m=1
C2[192] S3[192] 0 5f m=1
C2[191] S3[191] 0 5f m=1
C2[190] S3[190] 0 5f m=1
C2[189] S3[189] 0 5f m=1
C2[188] S3[188] 0 5f m=1
C2[187] S3[187] 0 5f m=1
C2[186] S3[186] 0 5f m=1
C2[185] S3[185] 0 5f m=1
C2[184] S3[184] 0 5f m=1
C2[183] S3[183] 0 5f m=1
C2[182] S3[182] 0 5f m=1
C2[181] S3[181] 0 5f m=1
C2[180] S3[180] 0 5f m=1
C2[179] S3[179] 0 5f m=1
C2[178] S3[178] 0 5f m=1
C2[177] S3[177] 0 5f m=1
C2[176] S3[176] 0 5f m=1
C2[175] S3[175] 0 5f m=1
C2[174] S3[174] 0 5f m=1
C2[173] S3[173] 0 5f m=1
C2[172] S3[172] 0 5f m=1
C2[171] S3[171] 0 5f m=1
C2[170] S3[170] 0 5f m=1
C2[169] S3[169] 0 5f m=1
C2[168] S3[168] 0 5f m=1
C2[167] S3[167] 0 5f m=1
C2[166] S3[166] 0 5f m=1
C2[165] S3[165] 0 5f m=1
C2[164] S3[164] 0 5f m=1
C2[163] S3[163] 0 5f m=1
C2[162] S3[162] 0 5f m=1
C2[161] S3[161] 0 5f m=1
C2[160] S3[160] 0 5f m=1
C2[159] S3[159] 0 5f m=1
C2[158] S3[158] 0 5f m=1
C2[157] S3[157] 0 5f m=1
C2[156] S3[156] 0 5f m=1
C2[155] S3[155] 0 5f m=1
C2[154] S3[154] 0 5f m=1
C2[153] S3[153] 0 5f m=1
C2[152] S3[152] 0 5f m=1
C2[151] S3[151] 0 5f m=1
C2[150] S3[150] 0 5f m=1
C2[149] S3[149] 0 5f m=1
C2[148] S3[148] 0 5f m=1
C2[147] S3[147] 0 5f m=1
C2[146] S3[146] 0 5f m=1
C2[145] S3[145] 0 5f m=1
C2[144] S3[144] 0 5f m=1
C2[143] S3[143] 0 5f m=1
C2[142] S3[142] 0 5f m=1
C2[141] S3[141] 0 5f m=1
C2[140] S3[140] 0 5f m=1
C2[139] S3[139] 0 5f m=1
C2[138] S3[138] 0 5f m=1
C2[137] S3[137] 0 5f m=1
C2[136] S3[136] 0 5f m=1
C2[135] S3[135] 0 5f m=1
C2[134] S3[134] 0 5f m=1
C2[133] S3[133] 0 5f m=1
C2[132] S3[132] 0 5f m=1
C2[131] S3[131] 0 5f m=1
C2[130] S3[130] 0 5f m=1
C2[129] S3[129] 0 5f m=1
C2[128] S3[128] 0 5f m=1
C2[127] S3[127] 0 5f m=1
C2[126] S3[126] 0 5f m=1
C2[125] S3[125] 0 5f m=1
C2[124] S3[124] 0 5f m=1
C2[123] S3[123] 0 5f m=1
C2[122] S3[122] 0 5f m=1
C2[121] S3[121] 0 5f m=1
C2[120] S3[120] 0 5f m=1
C2[119] S3[119] 0 5f m=1
C2[118] S3[118] 0 5f m=1
C2[117] S3[117] 0 5f m=1
C2[116] S3[116] 0 5f m=1
C2[115] S3[115] 0 5f m=1
C2[114] S3[114] 0 5f m=1
C2[113] S3[113] 0 5f m=1
C2[112] S3[112] 0 5f m=1
C2[111] S3[111] 0 5f m=1
C2[110] S3[110] 0 5f m=1
C2[109] S3[109] 0 5f m=1
C2[108] S3[108] 0 5f m=1
C2[107] S3[107] 0 5f m=1
C2[106] S3[106] 0 5f m=1
C2[105] S3[105] 0 5f m=1
C2[104] S3[104] 0 5f m=1
C2[103] S3[103] 0 5f m=1
C2[102] S3[102] 0 5f m=1
C2[101] S3[101] 0 5f m=1
C2[100] S3[100] 0 5f m=1
C2[99] S3[99] 0 5f m=1
C2[98] S3[98] 0 5f m=1
C2[97] S3[97] 0 5f m=1
C2[96] S3[96] 0 5f m=1
C2[95] S3[95] 0 5f m=1
C2[94] S3[94] 0 5f m=1
C2[93] S3[93] 0 5f m=1
C2[92] S3[92] 0 5f m=1
C2[91] S3[91] 0 5f m=1
C2[90] S3[90] 0 5f m=1
C2[89] S3[89] 0 5f m=1
C2[88] S3[88] 0 5f m=1
C2[87] S3[87] 0 5f m=1
C2[86] S3[86] 0 5f m=1
C2[85] S3[85] 0 5f m=1
C2[84] S3[84] 0 5f m=1
C2[83] S3[83] 0 5f m=1
C2[82] S3[82] 0 5f m=1
C2[81] S3[81] 0 5f m=1
C2[80] S3[80] 0 5f m=1
C2[79] S3[79] 0 5f m=1
C2[78] S3[78] 0 5f m=1
C2[77] S3[77] 0 5f m=1
C2[76] S3[76] 0 5f m=1
C2[75] S3[75] 0 5f m=1
C2[74] S3[74] 0 5f m=1
C2[73] S3[73] 0 5f m=1
C2[72] S3[72] 0 5f m=1
C2[71] S3[71] 0 5f m=1
C2[70] S3[70] 0 5f m=1
C2[69] S3[69] 0 5f m=1
C2[68] S3[68] 0 5f m=1
C2[67] S3[67] 0 5f m=1
C2[66] S3[66] 0 5f m=1
C2[65] S3[65] 0 5f m=1
C2[64] S3[64] 0 5f m=1
C2[63] S3[63] 0 5f m=1
C2[62] S3[62] 0 5f m=1
C2[61] S3[61] 0 5f m=1
C2[60] S3[60] 0 5f m=1
C2[59] S3[59] 0 5f m=1
C2[58] S3[58] 0 5f m=1
C2[57] S3[57] 0 5f m=1
C2[56] S3[56] 0 5f m=1
C2[55] S3[55] 0 5f m=1
C2[54] S3[54] 0 5f m=1
C2[53] S3[53] 0 5f m=1
C2[52] S3[52] 0 5f m=1
C2[51] S3[51] 0 5f m=1
C2[50] S3[50] 0 5f m=1
C2[49] S3[49] 0 5f m=1
C2[48] S3[48] 0 5f m=1
C2[47] S3[47] 0 5f m=1
C2[46] S3[46] 0 5f m=1
C2[45] S3[45] 0 5f m=1
C2[44] S3[44] 0 5f m=1
C2[43] S3[43] 0 5f m=1
C2[42] S3[42] 0 5f m=1
C2[41] S3[41] 0 5f m=1
C2[40] S3[40] 0 5f m=1
C2[39] S3[39] 0 5f m=1
C2[38] S3[38] 0 5f m=1
C2[37] S3[37] 0 5f m=1
C2[36] S3[36] 0 5f m=1
C2[35] S3[35] 0 5f m=1
C2[34] S3[34] 0 5f m=1
C2[33] S3[33] 0 5f m=1
C2[32] S3[32] 0 5f m=1
C2[31] S3[31] 0 5f m=1
C2[30] S3[30] 0 5f m=1
C2[29] S3[29] 0 5f m=1
C2[28] S3[28] 0 5f m=1
C2[27] S3[27] 0 5f m=1
C2[26] S3[26] 0 5f m=1
C2[25] S3[25] 0 5f m=1
C2[24] S3[24] 0 5f m=1
C2[23] S3[23] 0 5f m=1
C2[22] S3[22] 0 5f m=1
C2[21] S3[21] 0 5f m=1
C2[20] S3[20] 0 5f m=1
C2[19] S3[19] 0 5f m=1
C2[18] S3[18] 0 5f m=1
C2[17] S3[17] 0 5f m=1
C2[16] S3[16] 0 5f m=1
C2[15] S3[15] 0 5f m=1
C2[14] S3[14] 0 5f m=1
C2[13] S3[13] 0 5f m=1
C2[12] S3[12] 0 5f m=1
C2[11] S3[11] 0 5f m=1
C2[10] S3[10] 0 5f m=1
C2[9] S3[9] 0 5f m=1
C2[8] S3[8] 0 5f m=1
C2[7] S3[7] 0 5f m=1
C2[6] S3[6] 0 5f m=1
C2[5] S3[5] 0 5f m=1
C2[4] S3[4] 0 5f m=1
C2[3] S3[3] 0 5f m=1
C2[2] S3[2] 0 5f m=1
C2[1] S3[1] 0 5f m=1
C2[0] S3[0] 0 5f m=1
C3[255] S2[31] 0 5f m=1
C3[254] S2[30] 0 5f m=1
C3[253] S2[29] 0 5f m=1
C3[252] S2[28] 0 5f m=1
C3[251] S2[27] 0 5f m=1
C3[250] S2[26] 0 5f m=1
C3[249] S2[25] 0 5f m=1
C3[248] S2[24] 0 5f m=1
C3[247] S2[23] 0 5f m=1
C3[246] S2[22] 0 5f m=1
C3[245] S2[21] 0 5f m=1
C3[244] S2[20] 0 5f m=1
C3[243] S2[19] 0 5f m=1
C3[242] S2[18] 0 5f m=1
C3[241] S2[17] 0 5f m=1
C3[240] S2[16] 0 5f m=1
C3[239] S2[15] 0 5f m=1
C3[238] S2[14] 0 5f m=1
C3[237] S2[13] 0 5f m=1
C3[236] S2[12] 0 5f m=1
C3[235] S2[11] 0 5f m=1
C3[234] S2[10] 0 5f m=1
C3[233] S2[9] 0 5f m=1
C3[232] S2[8] 0 5f m=1
C3[231] S2[7] 0 5f m=1
C3[230] S2[6] 0 5f m=1
C3[229] S2[5] 0 5f m=1
C3[228] S2[4] 0 5f m=1
C3[227] S2[3] 0 5f m=1
C3[226] S2[2] 0 5f m=1
C3[225] S2[1] 0 5f m=1
C3[224] S2[0] 0 5f m=1
C3[223] S2[31] 0 5f m=1
C3[222] S2[30] 0 5f m=1
C3[221] S2[29] 0 5f m=1
C3[220] S2[28] 0 5f m=1
C3[219] S2[27] 0 5f m=1
C3[218] S2[26] 0 5f m=1
C3[217] S2[25] 0 5f m=1
C3[216] S2[24] 0 5f m=1
C3[215] S2[23] 0 5f m=1
C3[214] S2[22] 0 5f m=1
C3[213] S2[21] 0 5f m=1
C3[212] S2[20] 0 5f m=1
C3[211] S2[19] 0 5f m=1
C3[210] S2[18] 0 5f m=1
C3[209] S2[17] 0 5f m=1
C3[208] S2[16] 0 5f m=1
C3[207] S2[15] 0 5f m=1
C3[206] S2[14] 0 5f m=1
C3[205] S2[13] 0 5f m=1
C3[204] S2[12] 0 5f m=1
C3[203] S2[11] 0 5f m=1
C3[202] S2[10] 0 5f m=1
C3[201] S2[9] 0 5f m=1
C3[200] S2[8] 0 5f m=1
C3[199] S2[7] 0 5f m=1
C3[198] S2[6] 0 5f m=1
C3[197] S2[5] 0 5f m=1
C3[196] S2[4] 0 5f m=1
C3[195] S2[3] 0 5f m=1
C3[194] S2[2] 0 5f m=1
C3[193] S2[1] 0 5f m=1
C3[192] S2[0] 0 5f m=1
C3[191] S2[31] 0 5f m=1
C3[190] S2[30] 0 5f m=1
C3[189] S2[29] 0 5f m=1
C3[188] S2[28] 0 5f m=1
C3[187] S2[27] 0 5f m=1
C3[186] S2[26] 0 5f m=1
C3[185] S2[25] 0 5f m=1
C3[184] S2[24] 0 5f m=1
C3[183] S2[23] 0 5f m=1
C3[182] S2[22] 0 5f m=1
C3[181] S2[21] 0 5f m=1
C3[180] S2[20] 0 5f m=1
C3[179] S2[19] 0 5f m=1
C3[178] S2[18] 0 5f m=1
C3[177] S2[17] 0 5f m=1
C3[176] S2[16] 0 5f m=1
C3[175] S2[15] 0 5f m=1
C3[174] S2[14] 0 5f m=1
C3[173] S2[13] 0 5f m=1
C3[172] S2[12] 0 5f m=1
C3[171] S2[11] 0 5f m=1
C3[170] S2[10] 0 5f m=1
C3[169] S2[9] 0 5f m=1
C3[168] S2[8] 0 5f m=1
C3[167] S2[7] 0 5f m=1
C3[166] S2[6] 0 5f m=1
C3[165] S2[5] 0 5f m=1
C3[164] S2[4] 0 5f m=1
C3[163] S2[3] 0 5f m=1
C3[162] S2[2] 0 5f m=1
C3[161] S2[1] 0 5f m=1
C3[160] S2[0] 0 5f m=1
C3[159] S2[31] 0 5f m=1
C3[158] S2[30] 0 5f m=1
C3[157] S2[29] 0 5f m=1
C3[156] S2[28] 0 5f m=1
C3[155] S2[27] 0 5f m=1
C3[154] S2[26] 0 5f m=1
C3[153] S2[25] 0 5f m=1
C3[152] S2[24] 0 5f m=1
C3[151] S2[23] 0 5f m=1
C3[150] S2[22] 0 5f m=1
C3[149] S2[21] 0 5f m=1
C3[148] S2[20] 0 5f m=1
C3[147] S2[19] 0 5f m=1
C3[146] S2[18] 0 5f m=1
C3[145] S2[17] 0 5f m=1
C3[144] S2[16] 0 5f m=1
C3[143] S2[15] 0 5f m=1
C3[142] S2[14] 0 5f m=1
C3[141] S2[13] 0 5f m=1
C3[140] S2[12] 0 5f m=1
C3[139] S2[11] 0 5f m=1
C3[138] S2[10] 0 5f m=1
C3[137] S2[9] 0 5f m=1
C3[136] S2[8] 0 5f m=1
C3[135] S2[7] 0 5f m=1
C3[134] S2[6] 0 5f m=1
C3[133] S2[5] 0 5f m=1
C3[132] S2[4] 0 5f m=1
C3[131] S2[3] 0 5f m=1
C3[130] S2[2] 0 5f m=1
C3[129] S2[1] 0 5f m=1
C3[128] S2[0] 0 5f m=1
C3[127] S2[31] 0 5f m=1
C3[126] S2[30] 0 5f m=1
C3[125] S2[29] 0 5f m=1
C3[124] S2[28] 0 5f m=1
C3[123] S2[27] 0 5f m=1
C3[122] S2[26] 0 5f m=1
C3[121] S2[25] 0 5f m=1
C3[120] S2[24] 0 5f m=1
C3[119] S2[23] 0 5f m=1
C3[118] S2[22] 0 5f m=1
C3[117] S2[21] 0 5f m=1
C3[116] S2[20] 0 5f m=1
C3[115] S2[19] 0 5f m=1
C3[114] S2[18] 0 5f m=1
C3[113] S2[17] 0 5f m=1
C3[112] S2[16] 0 5f m=1
C3[111] S2[15] 0 5f m=1
C3[110] S2[14] 0 5f m=1
C3[109] S2[13] 0 5f m=1
C3[108] S2[12] 0 5f m=1
C3[107] S2[11] 0 5f m=1
C3[106] S2[10] 0 5f m=1
C3[105] S2[9] 0 5f m=1
C3[104] S2[8] 0 5f m=1
C3[103] S2[7] 0 5f m=1
C3[102] S2[6] 0 5f m=1
C3[101] S2[5] 0 5f m=1
C3[100] S2[4] 0 5f m=1
C3[99] S2[3] 0 5f m=1
C3[98] S2[2] 0 5f m=1
C3[97] S2[1] 0 5f m=1
C3[96] S2[0] 0 5f m=1
C3[95] S2[31] 0 5f m=1
C3[94] S2[30] 0 5f m=1
C3[93] S2[29] 0 5f m=1
C3[92] S2[28] 0 5f m=1
C3[91] S2[27] 0 5f m=1
C3[90] S2[26] 0 5f m=1
C3[89] S2[25] 0 5f m=1
C3[88] S2[24] 0 5f m=1
C3[87] S2[23] 0 5f m=1
C3[86] S2[22] 0 5f m=1
C3[85] S2[21] 0 5f m=1
C3[84] S2[20] 0 5f m=1
C3[83] S2[19] 0 5f m=1
C3[82] S2[18] 0 5f m=1
C3[81] S2[17] 0 5f m=1
C3[80] S2[16] 0 5f m=1
C3[79] S2[15] 0 5f m=1
C3[78] S2[14] 0 5f m=1
C3[77] S2[13] 0 5f m=1
C3[76] S2[12] 0 5f m=1
C3[75] S2[11] 0 5f m=1
C3[74] S2[10] 0 5f m=1
C3[73] S2[9] 0 5f m=1
C3[72] S2[8] 0 5f m=1
C3[71] S2[7] 0 5f m=1
C3[70] S2[6] 0 5f m=1
C3[69] S2[5] 0 5f m=1
C3[68] S2[4] 0 5f m=1
C3[67] S2[3] 0 5f m=1
C3[66] S2[2] 0 5f m=1
C3[65] S2[1] 0 5f m=1
C3[64] S2[0] 0 5f m=1
C3[63] S2[31] 0 5f m=1
C3[62] S2[30] 0 5f m=1
C3[61] S2[29] 0 5f m=1
C3[60] S2[28] 0 5f m=1
C3[59] S2[27] 0 5f m=1
C3[58] S2[26] 0 5f m=1
C3[57] S2[25] 0 5f m=1
C3[56] S2[24] 0 5f m=1
C3[55] S2[23] 0 5f m=1
C3[54] S2[22] 0 5f m=1
C3[53] S2[21] 0 5f m=1
C3[52] S2[20] 0 5f m=1
C3[51] S2[19] 0 5f m=1
C3[50] S2[18] 0 5f m=1
C3[49] S2[17] 0 5f m=1
C3[48] S2[16] 0 5f m=1
C3[47] S2[15] 0 5f m=1
C3[46] S2[14] 0 5f m=1
C3[45] S2[13] 0 5f m=1
C3[44] S2[12] 0 5f m=1
C3[43] S2[11] 0 5f m=1
C3[42] S2[10] 0 5f m=1
C3[41] S2[9] 0 5f m=1
C3[40] S2[8] 0 5f m=1
C3[39] S2[7] 0 5f m=1
C3[38] S2[6] 0 5f m=1
C3[37] S2[5] 0 5f m=1
C3[36] S2[4] 0 5f m=1
C3[35] S2[3] 0 5f m=1
C3[34] S2[2] 0 5f m=1
C3[33] S2[1] 0 5f m=1
C3[32] S2[0] 0 5f m=1
C3[31] S2[31] 0 5f m=1
C3[30] S2[30] 0 5f m=1
C3[29] S2[29] 0 5f m=1
C3[28] S2[28] 0 5f m=1
C3[27] S2[27] 0 5f m=1
C3[26] S2[26] 0 5f m=1
C3[25] S2[25] 0 5f m=1
C3[24] S2[24] 0 5f m=1
C3[23] S2[23] 0 5f m=1
C3[22] S2[22] 0 5f m=1
C3[21] S2[21] 0 5f m=1
C3[20] S2[20] 0 5f m=1
C3[19] S2[19] 0 5f m=1
C3[18] S2[18] 0 5f m=1
C3[17] S2[17] 0 5f m=1
C3[16] S2[16] 0 5f m=1
C3[15] S2[15] 0 5f m=1
C3[14] S2[14] 0 5f m=1
C3[13] S2[13] 0 5f m=1
C3[12] S2[12] 0 5f m=1
C3[11] S2[11] 0 5f m=1
C3[10] S2[10] 0 5f m=1
C3[9] S2[9] 0 5f m=1
C3[8] S2[8] 0 5f m=1
C3[7] S2[7] 0 5f m=1
C3[6] S2[6] 0 5f m=1
C3[5] S2[5] 0 5f m=1
C3[4] S2[4] 0 5f m=1
C3[3] S2[3] 0 5f m=1
C3[2] S2[2] 0 5f m=1
C3[1] S2[1] 0 5f m=1
C3[0] S2[0] 0 5f m=1
C6 COUT3 0 5f m=1
C1 COUT2 0 5f m=1
C4[31] S1[31] 0 5f m=1
C4[30] S1[30] 0 5f m=1
C4[29] S1[29] 0 5f m=1
C4[28] S1[28] 0 5f m=1
C4[27] S1[27] 0 5f m=1
C4[26] S1[26] 0 5f m=1
C4[25] S1[25] 0 5f m=1
C4[24] S1[24] 0 5f m=1
C4[23] S1[23] 0 5f m=1
C4[22] S1[22] 0 5f m=1
C4[21] S1[21] 0 5f m=1
C4[20] S1[20] 0 5f m=1
C4[19] S1[19] 0 5f m=1
C4[18] S1[18] 0 5f m=1
C4[17] S1[17] 0 5f m=1
C4[16] S1[16] 0 5f m=1
C4[15] S1[15] 0 5f m=1
C4[14] S1[14] 0 5f m=1
C4[13] S1[13] 0 5f m=1
C4[12] S1[12] 0 5f m=1
C4[11] S1[11] 0 5f m=1
C4[10] S1[10] 0 5f m=1
C4[9] S1[9] 0 5f m=1
C4[8] S1[8] 0 5f m=1
C4[7] S1[7] 0 5f m=1
C4[6] S1[6] 0 5f m=1
C4[5] S1[5] 0 5f m=1
C4[4] S1[4] 0 5f m=1
C4[3] S1[3] 0 5f m=1
C4[2] S1[2] 0 5f m=1
C4[1] S1[1] 0 5f m=1
C4[0] S1[0] 0 5f m=1
C5[31] CARRY1[31] 0 5f m=1
C5[30] CARRY1[30] 0 5f m=1
C5[29] CARRY1[29] 0 5f m=1
C5[28] CARRY1[28] 0 5f m=1
C5[27] CARRY1[27] 0 5f m=1
C5[26] CARRY1[26] 0 5f m=1
C5[25] CARRY1[25] 0 5f m=1
C5[24] CARRY1[24] 0 5f m=1
C5[23] CARRY1[23] 0 5f m=1
C5[22] CARRY1[22] 0 5f m=1
C5[21] CARRY1[21] 0 5f m=1
C5[20] CARRY1[20] 0 5f m=1
C5[19] CARRY1[19] 0 5f m=1
C5[18] CARRY1[18] 0 5f m=1
C5[17] CARRY1[17] 0 5f m=1
C5[16] CARRY1[16] 0 5f m=1
C5[15] CARRY1[15] 0 5f m=1
C5[14] CARRY1[14] 0 5f m=1
C5[13] CARRY1[13] 0 5f m=1
C5[12] CARRY1[12] 0 5f m=1
C5[11] CARRY1[11] 0 5f m=1
C5[10] CARRY1[10] 0 5f m=1
C5[9] CARRY1[9] 0 5f m=1
C5[8] CARRY1[8] 0 5f m=1
C5[7] CARRY1[7] 0 5f m=1
C5[6] CARRY1[6] 0 5f m=1
C5[5] CARRY1[5] 0 5f m=1
C5[4] CARRY1[4] 0 5f m=1
C5[3] CARRY1[3] 0 5f m=1
C5[2] CARRY1[2] 0 5f m=1
C5[1] CARRY1[1] 0 5f m=1
C5[0] CARRY1[0] 0 5f m=1
**** begin user architecture code

.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice

[
set sky130_corner(tt) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(tt_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(mc) "
.param mc_mm_switch=0
.param mc_pr_switch=1
.include $::SKYWATER_MODELS/parameters/critical.spice
.include $::SKYWATER_MODELS/parameters/montecarlo.spice
"
return {}
]$sky130_corner(tt)






*.option method=gear
.param VCC=1.8
* generate following file with Simulation->Utile stimuli editor and pressing 'Translate'
.include stimuli_test_carry_lookahead.cir
.control
* save all
tran 0.4n 250n uic
write test_carry_lookahead_ngspice.raw
quit 0
.endc






**** end user architecture code
**.ends

* expanding   symbol:  sky130_tests/adder_256bit.sym # of pins=7
** sym_path: sky130_tests/adder_256bit.sym
** sch_path: sky130_tests/adder_256bit.sch
.subckt adder_256bit A[255] A[254] A[253] A[252] A[251] A[250] A[249] A[248] A[247] A[246] A[245]
+ A[244] A[243] A[242] A[241] A[240] A[239] A[238] A[237] A[236] A[235] A[234] A[233] A[232] A[231] A[230]
+ A[229] A[228] A[227] A[226] A[225] A[224] A[223] A[222] A[221] A[220] A[219] A[218] A[217] A[216] A[215]
+ A[214] A[213] A[212] A[211] A[210] A[209] A[208] A[207] A[206] A[205] A[204] A[203] A[202] A[201] A[200]
+ A[199] A[198] A[197] A[196] A[195] A[194] A[193] A[192] A[191] A[190] A[189] A[188] A[187] A[186] A[185]
+ A[184] A[183] A[182] A[181] A[180] A[179] A[178] A[177] A[176] A[175] A[174] A[173] A[172] A[171] A[170]
+ A[169] A[168] A[167] A[166] A[165] A[164] A[163] A[162] A[161] A[160] A[159] A[158] A[157] A[156] A[155]
+ A[154] A[153] A[152] A[151] A[150] A[149] A[148] A[147] A[146] A[145] A[144] A[143] A[142] A[141] A[140]
+ A[139] A[138] A[137] A[136] A[135] A[134] A[133] A[132] A[131] A[130] A[129] A[128] A[127] A[126] A[125]
+ A[124] A[123] A[122] A[121] A[120] A[119] A[118] A[117] A[116] A[115] A[114] A[113] A[112] A[111] A[110]
+ A[109] A[108] A[107] A[106] A[105] A[104] A[103] A[102] A[101] A[100] A[99] A[98] A[97] A[96] A[95] A[94]
+ A[93] A[92] A[91] A[90] A[89] A[88] A[87] A[86] A[85] A[84] A[83] A[82] A[81] A[80] A[79] A[78] A[77]
+ A[76] A[75] A[74] A[73] A[72] A[71] A[70] A[69] A[68] A[67] A[66] A[65] A[64] A[63] A[62] A[61] A[60]
+ A[59] A[58] A[57] A[56] A[55] A[54] A[53] A[52] A[51] A[50] A[49] A[48] A[47] A[46] A[45] A[44] A[43]
+ A[42] A[41] A[40] A[39] A[38] A[37] A[36] A[35] A[34] A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8]
+ A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] S[255] S[254] S[253] S[252] S[251] S[250] S[249] S[248] S[247]
+ S[246] S[245] S[244] S[243] S[242] S[241] S[240] S[239] S[238] S[237] S[236] S[235] S[234] S[233] S[232]
+ S[231] S[230] S[229] S[228] S[227] S[226] S[225] S[224] S[223] S[222] S[221] S[220] S[219] S[218] S[217]
+ S[216] S[215] S[214] S[213] S[212] S[211] S[210] S[209] S[208] S[207] S[206] S[205] S[204] S[203] S[202]
+ S[201] S[200] S[199] S[198] S[197] S[196] S[195] S[194] S[193] S[192] S[191] S[190] S[189] S[188] S[187]
+ S[186] S[185] S[184] S[183] S[182] S[181] S[180] S[179] S[178] S[177] S[176] S[175] S[174] S[173] S[172]
+ S[171] S[170] S[169] S[168] S[167] S[166] S[165] S[164] S[163] S[162] S[161] S[160] S[159] S[158] S[157]
+ S[156] S[155] S[154] S[153] S[152] S[151] S[150] S[149] S[148] S[147] S[146] S[145] S[144] S[143] S[142]
+ S[141] S[140] S[139] S[138] S[137] S[136] S[135] S[134] S[133] S[132] S[131] S[130] S[129] S[128] S[127]
+ S[126] S[125] S[124] S[123] S[122] S[121] S[120] S[119] S[118] S[117] S[116] S[115] S[114] S[113] S[112]
+ S[111] S[110] S[109] S[108] S[107] S[106] S[105] S[104] S[103] S[102] S[101] S[100] S[99] S[98] S[97]
+ S[96] S[95] S[94] S[93] S[92] S[91] S[90] S[89] S[88] S[87] S[86] S[85] S[84] S[83] S[82] S[81] S[80]
+ S[79] S[78] S[77] S[76] S[75] S[74] S[73] S[72] S[71] S[70] S[69] S[68] S[67] S[66] S[65] S[64] S[63]
+ S[62] S[61] S[60] S[59] S[58] S[57] S[56] S[55] S[54] S[53] S[52] S[51] S[50] S[49] S[48] S[47] S[46]
+ S[45] S[44] S[43] S[42] S[41] S[40] S[39] S[38] S[37] S[36] S[35] S[34] S[33] S[32] S[31] S[30] S[29]
+ S[28] S[27] S[26] S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16] S[15] S[14] S[13] S[12]
+ S[11] S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[255] B[254] B[253] B[252] B[251] B[250]
+ B[249] B[248] B[247] B[246] B[245] B[244] B[243] B[242] B[241] B[240] B[239] B[238] B[237] B[236] B[235]
+ B[234] B[233] B[232] B[231] B[230] B[229] B[228] B[227] B[226] B[225] B[224] B[223] B[222] B[221] B[220]
+ B[219] B[218] B[217] B[216] B[215] B[214] B[213] B[212] B[211] B[210] B[209] B[208] B[207] B[206] B[205]
+ B[204] B[203] B[202] B[201] B[200] B[199] B[198] B[197] B[196] B[195] B[194] B[193] B[192] B[191] B[190]
+ B[189] B[188] B[187] B[186] B[185] B[184] B[183] B[182] B[181] B[180] B[179] B[178] B[177] B[176] B[175]
+ B[174] B[173] B[172] B[171] B[170] B[169] B[168] B[167] B[166] B[165] B[164] B[163] B[162] B[161] B[160]
+ B[159] B[158] B[157] B[156] B[155] B[154] B[153] B[152] B[151] B[150] B[149] B[148] B[147] B[146] B[145]
+ B[144] B[143] B[142] B[141] B[140] B[139] B[138] B[137] B[136] B[135] B[134] B[133] B[132] B[131] B[130]
+ B[129] B[128] B[127] B[126] B[125] B[124] B[123] B[122] B[121] B[120] B[119] B[118] B[117] B[116] B[115]
+ B[114] B[113] B[112] B[111] B[110] B[109] B[108] B[107] B[106] B[105] B[104] B[103] B[102] B[101] B[100]
+ B[99] B[98] B[97] B[96] B[95] B[94] B[93] B[92] B[91] B[90] B[89] B[88] B[87] B[86] B[85] B[84] B[83]
+ B[82] B[81] B[80] B[79] B[78] B[77] B[76] B[75] B[74] B[73] B[72] B[71] B[70] B[69] B[68] B[67] B[66]
+ B[65] B[64] B[63] B[62] B[61] B[60] B[59] B[58] B[57] B[56] B[55] B[54] B[53] B[52] B[51] B[50] B[49]
+ B[48] B[47] B[46] B[45] B[44] B[43] B[42] B[41] B[40] B[39] B[38] B[37] B[36] B[35] B[34] B[33] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] COUT SG CIN SP
*.ipin
*+ A[255],A[254],A[253],A[252],A[251],A[250],A[249],A[248],A[247],A[246],A[245],A[244],A[243],A[242],A[241],A[240],A[239],A[238],A[237],A[236],A[235],A[234],A[233],A[232],A[231],A[230],A[229],A[228],A[227],A[226],A[225],A[224],A[223],A[222],A[221],A[220],A[219],A[218],A[217],A[216],A[215],A[214],A[213],A[212],A[211],A[210],A[209],A[208],A[207],A[206],A[205],A[204],A[203],A[202],A[201],A[200],A[199],A[198],A[197],A[196],A[195],A[194],A[193],A[192],A[191],A[190],A[189],A[188],A[187],A[186],A[185],A[184],A[183],A[182],A[181],A[180],A[179],A[178],A[177],A[176],A[175],A[174],A[173],A[172],A[171],A[170],A[169],A[168],A[167],A[166],A[165],A[164],A[163],A[162],A[161],A[160],A[159],A[158],A[157],A[156],A[155],A[154],A[153],A[152],A[151],A[150],A[149],A[148],A[147],A[146],A[145],A[144],A[143],A[142],A[141],A[140],A[139],A[138],A[137],A[136],A[135],A[134],A[133],A[132],A[131],A[130],A[129],A[128],A[127],A[126],A[125],A[124],A[123],A[122],A[121],A[120],A[119],A[118],A[117],A[116],A[115],A[114],A[113],A[112],A[111],A[110],A[109],A[108],A[107],A[106],A[105],A[104],A[103],A[102],A[101],A[100],A[99],A[98],A[97],A[96],A[95],A[94],A[93],A[92],A[91],A[90],A[89],A[88],A[87],A[86],A[85],A[84],A[83],A[82],A[81],A[80],A[79],A[78],A[77],A[76],A[75],A[74],A[73],A[72],A[71],A[70],A[69],A[68],A[67],A[66],A[65],A[64],A[63],A[62],A[61],A[60],A[59],A[58],A[57],A[56],A[55],A[54],A[53],A[52],A[51],A[50],A[49],A[48],A[47],A[46],A[45],A[44],A[43],A[42],A[41],A[40],A[39],A[38],A[37],A[36],A[35],A[34],A[33],A[32],A[31],A[30],A[29],A[28],A[27],A[26],A[25],A[24],A[23],A[22],A[21],A[20],A[19],A[18],A[17],A[16],A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*.ipin
*+ B[255],B[254],B[253],B[252],B[251],B[250],B[249],B[248],B[247],B[246],B[245],B[244],B[243],B[242],B[241],B[240],B[239],B[238],B[237],B[236],B[235],B[234],B[233],B[232],B[231],B[230],B[229],B[228],B[227],B[226],B[225],B[224],B[223],B[222],B[221],B[220],B[219],B[218],B[217],B[216],B[215],B[214],B[213],B[212],B[211],B[210],B[209],B[208],B[207],B[206],B[205],B[204],B[203],B[202],B[201],B[200],B[199],B[198],B[197],B[196],B[195],B[194],B[193],B[192],B[191],B[190],B[189],B[188],B[187],B[186],B[185],B[184],B[183],B[182],B[181],B[180],B[179],B[178],B[177],B[176],B[175],B[174],B[173],B[172],B[171],B[170],B[169],B[168],B[167],B[166],B[165],B[164],B[163],B[162],B[161],B[160],B[159],B[158],B[157],B[156],B[155],B[154],B[153],B[152],B[151],B[150],B[149],B[148],B[147],B[146],B[145],B[144],B[143],B[142],B[141],B[140],B[139],B[138],B[137],B[136],B[135],B[134],B[133],B[132],B[131],B[130],B[129],B[128],B[127],B[126],B[125],B[124],B[123],B[122],B[121],B[120],B[119],B[118],B[117],B[116],B[115],B[114],B[113],B[112],B[111],B[110],B[109],B[108],B[107],B[106],B[105],B[104],B[103],B[102],B[101],B[100],B[99],B[98],B[97],B[96],B[95],B[94],B[93],B[92],B[91],B[90],B[89],B[88],B[87],B[86],B[85],B[84],B[83],B[82],B[81],B[80],B[79],B[78],B[77],B[76],B[75],B[74],B[73],B[72],B[71],B[70],B[69],B[68],B[67],B[66],B[65],B[64],B[63],B[62],B[61],B[60],B[59],B[58],B[57],B[56],B[55],B[54],B[53],B[52],B[51],B[50],B[49],B[48],B[47],B[46],B[45],B[44],B[43],B[42],B[41],B[40],B[39],B[38],B[37],B[36],B[35],B[34],B[33],B[32],B[31],B[30],B[29],B[28],B[27],B[26],B[25],B[24],B[23],B[22],B[21],B[20],B[19],B[18],B[17],B[16],B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.ipin CIN
*.opin
*+ S[255],S[254],S[253],S[252],S[251],S[250],S[249],S[248],S[247],S[246],S[245],S[244],S[243],S[242],S[241],S[240],S[239],S[238],S[237],S[236],S[235],S[234],S[233],S[232],S[231],S[230],S[229],S[228],S[227],S[226],S[225],S[224],S[223],S[222],S[221],S[220],S[219],S[218],S[217],S[216],S[215],S[214],S[213],S[212],S[211],S[210],S[209],S[208],S[207],S[206],S[205],S[204],S[203],S[202],S[201],S[200],S[199],S[198],S[197],S[196],S[195],S[194],S[193],S[192],S[191],S[190],S[189],S[188],S[187],S[186],S[185],S[184],S[183],S[182],S[181],S[180],S[179],S[178],S[177],S[176],S[175],S[174],S[173],S[172],S[171],S[170],S[169],S[168],S[167],S[166],S[165],S[164],S[163],S[162],S[161],S[160],S[159],S[158],S[157],S[156],S[155],S[154],S[153],S[152],S[151],S[150],S[149],S[148],S[147],S[146],S[145],S[144],S[143],S[142],S[141],S[140],S[139],S[138],S[137],S[136],S[135],S[134],S[133],S[132],S[131],S[130],S[129],S[128],S[127],S[126],S[125],S[124],S[123],S[122],S[121],S[120],S[119],S[118],S[117],S[116],S[115],S[114],S[113],S[112],S[111],S[110],S[109],S[108],S[107],S[106],S[105],S[104],S[103],S[102],S[101],S[100],S[99],S[98],S[97],S[96],S[95],S[94],S[93],S[92],S[91],S[90],S[89],S[88],S[87],S[86],S[85],S[84],S[83],S[82],S[81],S[80],S[79],S[78],S[77],S[76],S[75],S[74],S[73],S[72],S[71],S[70],S[69],S[68],S[67],S[66],S[65],S[64],S[63],S[62],S[61],S[60],S[59],S[58],S[57],S[56],S[55],S[54],S[53],S[52],S[51],S[50],S[49],S[48],S[47],S[46],S[45],S[44],S[43],S[42],S[41],S[40],S[39],S[38],S[37],S[36],S[35],S[34],S[33],S[32],S[31],S[30],S[29],S[28],S[27],S[26],S[25],S[24],S[23],S[22],S[21],S[20],S[19],S[18],S[17],S[16],S[15],S[14],S[13],S[12],S[11],S[10],S[9],S[8],S[7],S[6],S[5],S[4],S[3],S[2],S[1],S[0]
*.opin COUT
*.opin SP
*.opin SG
xadd64[3] A[255] A[254] A[253] A[252] A[251] A[250] A[249] A[248] A[247] A[246] A[245] A[244] A[243]
+ A[242] A[241] A[240] A[239] A[238] A[237] A[236] A[235] A[234] A[233] A[232] A[231] A[230] A[229] A[228]
+ A[227] A[226] A[225] A[224] A[223] A[222] A[221] A[220] A[219] A[218] A[217] A[216] A[215] A[214] A[213]
+ A[212] A[211] A[210] A[209] A[208] A[207] A[206] A[205] A[204] A[203] A[202] A[201] A[200] A[199] A[198]
+ A[197] A[196] A[195] A[194] A[193] A[192] S[255] S[254] S[253] S[252] S[251] S[250] S[249] S[248] S[247]
+ S[246] S[245] S[244] S[243] S[242] S[241] S[240] S[239] S[238] S[237] S[236] S[235] S[234] S[233] S[232]
+ S[231] S[230] S[229] S[228] S[227] S[226] S[225] S[224] S[223] S[222] S[221] S[220] S[219] S[218] S[217]
+ S[216] S[215] S[214] S[213] S[212] S[211] S[210] S[209] S[208] S[207] S[206] S[205] S[204] S[203] S[202]
+ S[201] S[200] S[199] S[198] S[197] S[196] S[195] S[194] S[193] S[192] B[255] B[254] B[253] B[252] B[251]
+ B[250] B[249] B[248] B[247] B[246] B[245] B[244] B[243] B[242] B[241] B[240] B[239] B[238] B[237] B[236]
+ B[235] B[234] B[233] B[232] B[231] B[230] B[229] B[228] B[227] B[226] B[225] B[224] B[223] B[222] B[221]
+ B[220] B[219] B[218] B[217] B[216] B[215] B[214] B[213] B[212] B[211] B[210] B[209] B[208] B[207] B[206]
+ B[205] B[204] B[203] B[202] B[201] B[200] B[199] B[198] B[197] B[196] B[195] B[194] B[193] B[192] net1
+ G[3] C3 P[3] adder_64bit
xadd64[2] A[191] A[190] A[189] A[188] A[187] A[186] A[185] A[184] A[183] A[182] A[181] A[180] A[179]
+ A[178] A[177] A[176] A[175] A[174] A[173] A[172] A[171] A[170] A[169] A[168] A[167] A[166] A[165] A[164]
+ A[163] A[162] A[161] A[160] A[159] A[158] A[157] A[156] A[155] A[154] A[153] A[152] A[151] A[150] A[149]
+ A[148] A[147] A[146] A[145] A[144] A[143] A[142] A[141] A[140] A[139] A[138] A[137] A[136] A[135] A[134]
+ A[133] A[132] A[131] A[130] A[129] A[128] S[191] S[190] S[189] S[188] S[187] S[186] S[185] S[184] S[183]
+ S[182] S[181] S[180] S[179] S[178] S[177] S[176] S[175] S[174] S[173] S[172] S[171] S[170] S[169] S[168]
+ S[167] S[166] S[165] S[164] S[163] S[162] S[161] S[160] S[159] S[158] S[157] S[156] S[155] S[154] S[153]
+ S[152] S[151] S[150] S[149] S[148] S[147] S[146] S[145] S[144] S[143] S[142] S[141] S[140] S[139] S[138]
+ S[137] S[136] S[135] S[134] S[133] S[132] S[131] S[130] S[129] S[128] B[191] B[190] B[189] B[188] B[187]
+ B[186] B[185] B[184] B[183] B[182] B[181] B[180] B[179] B[178] B[177] B[176] B[175] B[174] B[173] B[172]
+ B[171] B[170] B[169] B[168] B[167] B[166] B[165] B[164] B[163] B[162] B[161] B[160] B[159] B[158] B[157]
+ B[156] B[155] B[154] B[153] B[152] B[151] B[150] B[149] B[148] B[147] B[146] B[145] B[144] B[143] B[142]
+ B[141] B[140] B[139] B[138] B[137] B[136] B[135] B[134] B[133] B[132] B[131] B[130] B[129] B[128] net1
+ G[2] C2 P[2] adder_64bit
xadd64[1] A[127] A[126] A[125] A[124] A[123] A[122] A[121] A[120] A[119] A[118] A[117] A[116] A[115]
+ A[114] A[113] A[112] A[111] A[110] A[109] A[108] A[107] A[106] A[105] A[104] A[103] A[102] A[101] A[100]
+ A[99] A[98] A[97] A[96] A[95] A[94] A[93] A[92] A[91] A[90] A[89] A[88] A[87] A[86] A[85] A[84] A[83]
+ A[82] A[81] A[80] A[79] A[78] A[77] A[76] A[75] A[74] A[73] A[72] A[71] A[70] A[69] A[68] A[67] A[66]
+ A[65] A[64] S[127] S[126] S[125] S[124] S[123] S[122] S[121] S[120] S[119] S[118] S[117] S[116] S[115]
+ S[114] S[113] S[112] S[111] S[110] S[109] S[108] S[107] S[106] S[105] S[104] S[103] S[102] S[101] S[100]
+ S[99] S[98] S[97] S[96] S[95] S[94] S[93] S[92] S[91] S[90] S[89] S[88] S[87] S[86] S[85] S[84] S[83]
+ S[82] S[81] S[80] S[79] S[78] S[77] S[76] S[75] S[74] S[73] S[72] S[71] S[70] S[69] S[68] S[67] S[66]
+ S[65] S[64] B[127] B[126] B[125] B[124] B[123] B[122] B[121] B[120] B[119] B[118] B[117] B[116] B[115]
+ B[114] B[113] B[112] B[111] B[110] B[109] B[108] B[107] B[106] B[105] B[104] B[103] B[102] B[101] B[100]
+ B[99] B[98] B[97] B[96] B[95] B[94] B[93] B[92] B[91] B[90] B[89] B[88] B[87] B[86] B[85] B[84] B[83]
+ B[82] B[81] B[80] B[79] B[78] B[77] B[76] B[75] B[74] B[73] B[72] B[71] B[70] B[69] B[68] B[67] B[66]
+ B[65] B[64] net1 G[1] C1 P[1] adder_64bit
xadd64[0] A[63] A[62] A[61] A[60] A[59] A[58] A[57] A[56] A[55] A[54] A[53] A[52] A[51] A[50] A[49]
+ A[48] A[47] A[46] A[45] A[44] A[43] A[42] A[41] A[40] A[39] A[38] A[37] A[36] A[35] A[34] A[33] A[32]
+ A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15]
+ A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] S[63] S[62] S[61] S[60]
+ S[59] S[58] S[57] S[56] S[55] S[54] S[53] S[52] S[51] S[50] S[49] S[48] S[47] S[46] S[45] S[44] S[43]
+ S[42] S[41] S[40] S[39] S[38] S[37] S[36] S[35] S[34] S[33] S[32] S[31] S[30] S[29] S[28] S[27] S[26]
+ S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16] S[15] S[14] S[13] S[12] S[11] S[10] S[9] S[8]
+ S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[63] B[62] B[61] B[60] B[59] B[58] B[57] B[56] B[55] B[54]
+ B[53] B[52] B[51] B[50] B[49] B[48] B[47] B[46] B[45] B[44] B[43] B[42] B[41] B[40] B[39] B[38] B[37]
+ B[36] B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20]
+ B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] net1 G[0] CIN P[0] adder_64bit
xcla SG SP C1 P[3] P[2] P[1] P[0] C2 G[3] G[2] G[1] G[0] C3 COUT CIN cla_4bits
* noconn #net1
.ends


* expanding   symbol:  sky130_tests/adder_32bit.sym # of pins=7
** sym_path: sky130_tests/adder_32bit.sym
** sch_path: sky130_tests/adder_32bit.sch
.subckt adder_32bit A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19]
+ A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ S[31] S[30] S[29] S[28] S[27] S[26] S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16] S[15]
+ S[14] S[13] S[12] S[11] S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11]
+ B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] COUT SG CIN SP
*.ipin
*+ A[31],A[30],A[29],A[28],A[27],A[26],A[25],A[24],A[23],A[22],A[21],A[20],A[19],A[18],A[17],A[16],A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*.ipin
*+ B[31],B[30],B[29],B[28],B[27],B[26],B[25],B[24],B[23],B[22],B[21],B[20],B[19],B[18],B[17],B[16],B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.ipin CIN
*.opin
*+ S[31],S[30],S[29],S[28],S[27],S[26],S[25],S[24],S[23],S[22],S[21],S[20],S[19],S[18],S[17],S[16],S[15],S[14],S[13],S[12],S[11],S[10],S[9],S[8],S[7],S[6],S[5],S[4],S[3],S[2],S[1],S[0]
*.opin SP
*.opin SG
*.opin COUT
x0[1] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17]
+ A[16] S[31] S[30] S[29] S[28] S[27] S[26] S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] net1 G[1]
+ C1 P[1] adder_16bit
x0[0] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] S[15]
+ S[14] S[13] S[12] S[11] S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[15] B[14] B[13] B[12]
+ B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] net1 G[0] CIN P[0] adder_16bit
xcla SG SP C1 P[1] P[0] COUT G[1] G[0] CIN cla_2bits
* noconn #net1
.ends


* expanding   symbol:  sky130_tests/adder_64bit.sym # of pins=7
** sym_path: sky130_tests/adder_64bit.sym
** sch_path: sky130_tests/adder_64bit.sch
.subckt adder_64bit A[63] A[62] A[61] A[60] A[59] A[58] A[57] A[56] A[55] A[54] A[53] A[52] A[51]
+ A[50] A[49] A[48] A[47] A[46] A[45] A[44] A[43] A[42] A[41] A[40] A[39] A[38] A[37] A[36] A[35] A[34]
+ A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17]
+ A[16] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] S[63] S[62]
+ S[61] S[60] S[59] S[58] S[57] S[56] S[55] S[54] S[53] S[52] S[51] S[50] S[49] S[48] S[47] S[46] S[45]
+ S[44] S[43] S[42] S[41] S[40] S[39] S[38] S[37] S[36] S[35] S[34] S[33] S[32] S[31] S[30] S[29] S[28]
+ S[27] S[26] S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16] S[15] S[14] S[13] S[12] S[11]
+ S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[63] B[62] B[61] B[60] B[59] B[58] B[57] B[56]
+ B[55] B[54] B[53] B[52] B[51] B[50] B[49] B[48] B[47] B[46] B[45] B[44] B[43] B[42] B[41] B[40] B[39]
+ B[38] B[37] B[36] B[35] B[34] B[33] B[32] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22]
+ B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4]
+ B[3] B[2] B[1] B[0] COUT SG CIN SP
*.ipin
*+ A[63],A[62],A[61],A[60],A[59],A[58],A[57],A[56],A[55],A[54],A[53],A[52],A[51],A[50],A[49],A[48],A[47],A[46],A[45],A[44],A[43],A[42],A[41],A[40],A[39],A[38],A[37],A[36],A[35],A[34],A[33],A[32],A[31],A[30],A[29],A[28],A[27],A[26],A[25],A[24],A[23],A[22],A[21],A[20],A[19],A[18],A[17],A[16],A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*.ipin
*+ B[63],B[62],B[61],B[60],B[59],B[58],B[57],B[56],B[55],B[54],B[53],B[52],B[51],B[50],B[49],B[48],B[47],B[46],B[45],B[44],B[43],B[42],B[41],B[40],B[39],B[38],B[37],B[36],B[35],B[34],B[33],B[32],B[31],B[30],B[29],B[28],B[27],B[26],B[25],B[24],B[23],B[22],B[21],B[20],B[19],B[18],B[17],B[16],B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.ipin CIN
*.opin
*+ S[63],S[62],S[61],S[60],S[59],S[58],S[57],S[56],S[55],S[54],S[53],S[52],S[51],S[50],S[49],S[48],S[47],S[46],S[45],S[44],S[43],S[42],S[41],S[40],S[39],S[38],S[37],S[36],S[35],S[34],S[33],S[32],S[31],S[30],S[29],S[28],S[27],S[26],S[25],S[24],S[23],S[22],S[21],S[20],S[19],S[18],S[17],S[16],S[15],S[14],S[13],S[12],S[11],S[10],S[9],S[8],S[7],S[6],S[5],S[4],S[3],S[2],S[1],S[0]
*.opin SP
*.opin SG
*.opin COUT
xadd16[3] A[63] A[62] A[61] A[60] A[59] A[58] A[57] A[56] A[55] A[54] A[53] A[52] A[51] A[50] A[49]
+ A[48] S[63] S[62] S[61] S[60] S[59] S[58] S[57] S[56] S[55] S[54] S[53] S[52] S[51] S[50] S[49] S[48]
+ B[63] B[62] B[61] B[60] B[59] B[58] B[57] B[56] B[55] B[54] B[53] B[52] B[51] B[50] B[49] B[48] net1 G[3]
+ C3 P[3] adder_16bit
xadd16[2] A[47] A[46] A[45] A[44] A[43] A[42] A[41] A[40] A[39] A[38] A[37] A[36] A[35] A[34] A[33]
+ A[32] S[47] S[46] S[45] S[44] S[43] S[42] S[41] S[40] S[39] S[38] S[37] S[36] S[35] S[34] S[33] S[32]
+ B[47] B[46] B[45] B[44] B[43] B[42] B[41] B[40] B[39] B[38] B[37] B[36] B[35] B[34] B[33] B[32] net1 G[2]
+ C2 P[2] adder_16bit
xadd16[1] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17]
+ A[16] S[31] S[30] S[29] S[28] S[27] S[26] S[25] S[24] S[23] S[22] S[21] S[20] S[19] S[18] S[17] S[16]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] net1 G[1]
+ C1 P[1] adder_16bit
xadd16[0] A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ S[15] S[14] S[13] S[12] S[11] S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[15] B[14] B[13]
+ B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] net1 G[0] CIN P[0] adder_16bit
xcla SG SP C1 P[3] P[2] P[1] P[0] C2 G[3] G[2] G[1] G[0] C3 COUT CIN cla_4bits
* noconn #net1
.ends


* expanding   symbol:  sky130_tests/cla_4bits.sym # of pins=9
** sym_path: sky130_tests/cla_4bits.sym
** sch_path: sky130_tests/cla_4bits.sch
.subckt cla_4bits SG SP C1 P[3] P[2] P[1] P[0] C2 G[3] G[2] G[1] G[0] C3 C4 C0
*.ipin P[3],P[2],P[1],P[0]
*.ipin G[3],G[2],G[1],G[0]
*.ipin C0
*.opin C4
*.opin C3
*.opin C2
*.opin C1
*.opin SG
*.opin SP
x1 P[0] VSS VSS VCC VCC net4 sky130_fd_sc_hd__inv_1
x2 net5 VSS VSS VCC VCC C1 sky130_fd_sc_hd__inv_1
x3 P[1] VSS VSS VCC VCC net2 sky130_fd_sc_hd__inv_1
x4 net8 VSS VSS VCC VCC C3 sky130_fd_sc_hd__inv_1
x5 G[1] VSS VSS VCC VCC net3 sky130_fd_sc_hd__inv_1
x6 net12 VSS VSS VCC VCC net13 sky130_fd_sc_hd__inv_1
x7 G[1] P[2] G[2] VSS VSS VCC VCC net12 sky130_fd_sc_hd__a21oi_1
x8 P[3] net13 G[3] VSS VSS VCC VCC net14 sky130_fd_sc_hd__a21oi_1
x9 C0 P[0] G[0] VSS VSS VCC VCC net5 sky130_fd_sc_hd__a21oi_1
x10 P[2] C2 G[2] VSS VSS VCC VCC net8 sky130_fd_sc_hd__a21oi_1
x11 G[0] VSS VSS VCC VCC net1 sky130_fd_sc_hd__inv_1
x12 net2 net5 net3 VSS VSS VCC VCC C2 sky130_fd_sc_hd__o21ai_1
x13 net5 net10 net14 VSS VSS VCC VCC C4 sky130_fd_sc_hd__o21ai_1
x14 net1 net10 net14 VSS VSS VCC VCC SG sky130_fd_sc_hd__o21ai_1
x15 net4 net10 VSS VSS VCC VCC SP sky130_fd_sc_hd__nor2_1
x16 P[1] P[2] P[3] VSS VSS VCC VCC net10 sky130_fd_sc_hd__nand3_1
C2 net4 0 5f m=1
C1 net10 0 5f m=1
C3 net1 0 5f m=1
C4 net14 0 5f m=1
C5 net2 0 5f m=1
C6 net5 0 5f m=1
C7 net3 0 5f m=1
C8 net8 0 5f m=1
C9 net13 0 5f m=1
C10 net12 0 5f m=1
C19[3] P[3] 0 5f m=1
C19[2] P[2] 0 5f m=1
C19[1] P[1] 0 5f m=1
C19[0] P[0] 0 5f m=1
C18[3] G[3] 0 5f m=1
C18[2] G[2] 0 5f m=1
C18[1] G[1] 0 5f m=1
C18[0] G[0] 0 5f m=1
C17 C0 0 5f m=1
.ends


* expanding   symbol:  sky130_tests/adder_16bit.sym # of pins=7
** sym_path: sky130_tests/adder_16bit.sym
** sch_path: sky130_tests/adder_16bit.sch
.subckt adder_16bit A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1]
+ A[0] S[15] S[14] S[13] S[12] S[11] S[10] S[9] S[8] S[7] S[6] S[5] S[4] S[3] S[2] S[1] S[0] B[15] B[14]
+ B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] COUT SG CIN SP
*.ipin A[15],A[14],A[13],A[12],A[11],A[10],A[9],A[8],A[7],A[6],A[5],A[4],A[3],A[2],A[1],A[0]
*.ipin B[15],B[14],B[13],B[12],B[11],B[10],B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.ipin CIN
*.opin S[15],S[14],S[13],S[12],S[11],S[10],S[9],S[8],S[7],S[6],S[5],S[4],S[3],S[2],S[1],S[0]
*.opin SP
*.opin SG
*.opin COUT
xadd4[3] A[15] A[14] A[13] A[12] S[15] S[14] S[13] S[12] B[15] B[14] B[13] B[12] net1 G[3] C3 P[3]
+ adder_4bit
xadd4[2] A[11] A[10] A[9] A[8] S[11] S[10] S[9] S[8] B[11] B[10] B[9] B[8] net1 G[2] C2 P[2]
+ adder_4bit
xadd4[1] A[7] A[6] A[5] A[4] S[7] S[6] S[5] S[4] B[7] B[6] B[5] B[4] net1 G[1] C1 P[1] adder_4bit
xadd4[0] A[3] A[2] A[1] A[0] S[3] S[2] S[1] S[0] B[3] B[2] B[1] B[0] net1 G[0] CIN P[0] adder_4bit
xcla SG SP C1 P[3] P[2] P[1] P[0] C2 G[3] G[2] G[1] G[0] C3 COUT CIN cla_4bits
* noconn #net1
.ends


* expanding   symbol:  sky130_tests/cla_2bits.sym # of pins=7
** sym_path: sky130_tests/cla_2bits.sym
** sch_path: sky130_tests/cla_2bits.sch
.subckt cla_2bits SG SP C1 P[1] P[0] C2 G[1] G[0] C0
*.ipin P[1],P[0]
*.ipin G[1],G[0]
*.ipin C0
*.opin C2
*.opin C1
*.opin SG
*.opin SP
x17 G[1] VSS VSS VCC VCC net1 sky130_fd_sc_hd__inv_1
x18 P[0] C0 G[0] VSS VSS VCC VCC net3 sky130_fd_sc_hd__a21oi_1
C17 net1 0 5f m=1
C18 net3 0 5f m=1
x19 G[0] P[1] VSS VSS VCC VCC net2 sky130_fd_sc_hd__nand2_1
C19 net2 0 5f m=1
x20 P[1] P[0] C0 VSS VSS VCC VCC net4 sky130_fd_sc_hd__nand3_1
C20 net4 0 5f m=1
x21 net1 net2 VSS VSS VCC VCC SG sky130_fd_sc_hd__nand2_1
x22 P[1] P[0] VSS VSS VCC VCC SP sky130_fd_sc_hd__and2_1
x23 net3 VSS VSS VCC VCC C1 sky130_fd_sc_hd__inv_1
x24 net1 net2 net4 VSS VSS VCC VCC C2 sky130_fd_sc_hd__nand3_1
.ends


* expanding   symbol:  sky130_tests/adder_4bit.sym # of pins=7
** sym_path: sky130_tests/adder_4bit.sym
** sch_path: sky130_tests/adder_4bit.sch
.subckt adder_4bit A[3] A[2] A[1] A[0] S[3] S[2] S[1] S[0] B[3] B[2] B[1] B[0] COUT SG CIN SP
*.ipin A[3],A[2],A[1],A[0]
*.ipin B[3],B[2],B[1],B[0]
*.ipin CIN
*.opin S[3],S[2],S[1],S[0]
*.opin SP
*.opin SG
*.opin COUT
xcla SG SP C1 P[3] P[2] P[1] P[0] C2 G[3] G[2] G[1] G[0] C3 COUT CIN cla_4bits
xadd1[3] S[3] A[3] B[3] G[3] C3 P[3] adder_1bit
xadd1[2] S[2] A[2] B[2] G[2] C2 P[2] adder_1bit
xadd1[1] S[1] A[1] B[1] G[1] C1 P[1] adder_1bit
xadd1[0] S[0] A[0] B[0] G[0] CIN P[0] adder_1bit
.ends


* expanding   symbol:  sky130_tests/adder_1bit.sym # of pins=6
** sym_path: sky130_tests/adder_1bit.sym
** sch_path: sky130_tests/adder_1bit.sch
.subckt adder_1bit S A B G CIN P
*.ipin A
*.ipin B
*.ipin CIN
*.opin S
*.opin P
*.opin G
x4 A B VSS VSS VCC VCC G sky130_fd_sc_hd__and2_1
x2 A B VSS VSS VCC VCC P sky130_fd_sc_hd__xor2_1
x3 P CIN VSS VSS VCC VCC S sky130_fd_sc_hd__xor2_1
C1 G 0 5f m=1
C2 P 0 5f m=1
C3 S 0 5f m=1
.ends

.GLOBAL VCC
.GLOBAL VSS
.end
