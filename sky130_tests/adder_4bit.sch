v {xschem version=2.8.2 file_version=1.0}
G {}
V {}
S {}
E {}
C {devices/ipin} 110 -220 0 0 {name=p1 lab=A[3:0]}
C {devices/ipin} 110 -190 0 0 {name=p2 lab=B[3:0]}
C {devices/ipin} 110 -150 0 0 {name=p3 lab=CIN}
C {devices/opin} 210 -220 0 0 {name=p4 lab=S[3:0]}
C {devices/title.sym} 160 -30 0 0 {name=l2}
C {sky130_tests/cla_4bits} 700 -390 0 0 {name=x2}
C {devices/lab_pin} 550 -440 0 0 {name=p14 lab=P[3:0]}
C {devices/lab_pin} 850 -400 0 1 {name=p15 lab=C1}
C {devices/lab_pin} 850 -380 0 1 {name=p16 lab=C2}
C {devices/lab_pin} 550 -420 0 0 {name=p17 lab=G[3:0]}
C {devices/lab_pin} 850 -360 0 1 {name=p18 lab=C3}
C {devices/lab_pin} 850 -340 0 1 {name=p19 lab=COUT}
C {devices/lab_pin} 550 -400 0 0 {name=p20 lab=CIN}
C {devices/lab_pin} 850 -440 0 1 {name=p36 lab=SG}
C {devices/lab_pin} 850 -420 0 1 {name=p37 lab=SP}
C {devices/opin} 210 -140 0 0 { name=p7 lab=SP }
C {devices/opin} 210 -160 0 0 { name=p8 lab=SG }
C {sky130_tests/adder_1bit} 700 -200 0 0 {name=x0[3:0]}
C {devices/lab_pin} 550 -180 0 0 {name=p9 lab=C3,C2,C1,CIN}
C {devices/lab_pin} 550 -220 0 0 {name=l3 lab=A[3:0]}
C {devices/lab_pin} 550 -200 0 0 {name=l6 lab=B[3:0]}
C {devices/lab_pin} 850 -220 0 1 {name=l7 lab=S[3:0]}
C {devices/lab_pin} 850 -200 0 1 {name=l8 lab=G[3:0]}
C {devices/lab_pin} 850 -180 0 1 {name=l9 lab=P[3:0]}
C {devices/opin} 210 -190 0 0 {name=p5 lab=COUT}
