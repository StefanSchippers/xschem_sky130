** sch_path: sky130_tests/tb_bandgap_opamp.sch
* Copyright 2021 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
**.subckt tb_bandgap_opamp VCC START PLUS OUT MINUS EN_N
*.ipin VCC
*.ipin START
*.ipin PLUS
*.opin OUT
*.ipin MINUS
*.ipin EN_N
x6 ADJ DIFFOUT_N START START_N VCC VSS passgate W_N=0.42 L_N=0.3 W_P=0.7 L_P=0.35 m=1
XC1 ADJ VSS sky130_fd_pr__cap_mim_m3_2 W=9 L=9 MF=2 m=2
x2 START_N START VCC VSS not W_N=1 L_N=0.15 W_P=2 L_P=0.15 m=1
x1 EN_N MINUS PLUS DIFFOUT_N VCC VSS ADJ zero_opamp
XM18 VTH1 VTH1 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2*(W + 0.29)'
+ ps='2*(W + 0.29)' nrd=0 nrs=0 sa=0 sb=0 sd=0 mult=1 m=1
I0 VSS VTH1 100n
x3 DIFFOUT_N OUT VCC VSS START_N START EN_N gain_stage WN=0.5 WP=1 wcap=9
E5 TEMPERAT VSS VOL=' temper '
* noconn TEMPERAT
* noconn EN_N
* noconn MINUS
* noconn PLUS
* noconn START
* noconn VCC
XM1 VTH2 VTH2 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2*(W + 0.29)'
+ ps='2*(W + 0.29)' nrd=0 nrs=0 sa=0 sb=0 sd=0 mult=1 m=1
I1 VSS VTH2 100n
**** begin user architecture code
[
set sky130_corner(tt) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(tt_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(mc) "
.param mc_mm_switch=0
.param mc_pr_switch=1
.include $::SKYWATER_MODELS/parameters/critical.spice
.include $::SKYWATER_MODELS/parameters/montecarlo.spice
"
return {}
]$sky130_corner(tt_mm)
**** end user architecture code
**.ends
**** begin user architecture code

* .option SCALE=1e-6
.option method=gear
.option savecurrents

* this experimental option enables mos model bin
* selection based on W/NF instead of W
.option wnflag=1


.param VCCGAUSS = agauss(1.8, 0.05, 1)
.param VCC = 'VCCGAUSS'
** use following line to remove VCC variations
* .param VCC = 1.8

.param TEMPGAUSS = agauss(40, 30, 1)
.option temp = 'TEMPGAUSS'
** use following line to remove temperature variations
* .option temp = 25

.include stimuli_tb_bandgap_opamp.cir
.control
  setseed 11
  reset
  let run=0
  dowhile run <= 100
    save all
    tran 1n 2500n uic
    print run
    print @m.x1.xml.msky130_fd_pr__pfet_01v8_lvt[vth]
    print @m.x1.xmr.msky130_fd_pr__pfet_01v8_lvt[vth]

    remzerovec
    write tb_bandgap_opamp.raw
    set appendwrite
    reset
    let run = run + 1
  end
.endc


**** end user architecture code
.end
