** sch_path: sky130_tests/test_varactor.sch
* Copyright 2020 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
**.subckt test_varactor
I1 0 G pwl 0 0 1000n 0 1010n 100n
XC3 G 0 0 sky130_fd_pr__cap_var_lvt W=5 L=5 VM=1 m=1
R1 G REF 1G m=1
I2 0 G1 pwl 0 0 1000n 0 1010n 100n
R2 G1 REF 1G m=1
XM1 net1 G1 net1 sky130_fd_pr__nfet_01v8_lvt W=5 L=5 ad=[expr 5 *0.29] pd=[expr 2*(5 + 0.29)]
+ as=[expr 5 *0.29] ps=[expr 2*(5 + 0.29)] nrd=[expr 0.29/5 ] nrs=[expr 0.29/5 ] sa=0 sb=0 sd=0 nf=1 mult=1
+ m=1
I3 0 G2 pwl 0 0 1000n 0 1010n 100n
R3 G2 REF 1G m=1
C1 G2 0 0.19p m=1
V1 REF 0 -2
**** begin user architecture code


.control
tran 10n 6u
plot g g1 g2
write test_varactor.raw
.endc



**** end user architecture code
**.ends
.end
