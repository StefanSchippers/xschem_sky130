** sch_path: sky130_tests/montecarlo_mismatch_sim.sch
**.subckt montecarlo_mismatch_sim
Vprobe2 net1 VM 0
VICM VCM GND dc 0.85 ac 0
C1 net1 GND 5p m=1
V3 VDD GND 1.8
x2 VDD VM VCM net1 GND ota1tb
.save v(vm)
.save v(vcm)
**** begin user architecture code


.options savecurrents
.control
 let runs=1000
 let r=0
 dowhile r < runs
   reset
   op
   let vdiff = v(vm,vcm)
   let run=r
   remzerovec
   write montecarlo_mismatch_sim.raw
   set appendwrite
   print v(vm,vcm)
   let r = r + 1
 end
.endc


[
set sky130_corner(tt) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(tt_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(mc) "
.param mc_mm_switch=0
.param mc_pr_switch=1
.include $::SKYWATER_MODELS/parameters/critical.spice
.include $::SKYWATER_MODELS/parameters/montecarlo.spice
"
return {}
]$sky130_corner(tt_mm)
**** end user architecture code
**.ends

* expanding   symbol:  sky130_tests/ota1tb.sym # of pins=5
** sym_path: sky130_tests/ota1tb.sym
** sch_path: sky130_tests/ota1tb.sch
.subckt ota1tb VDD minus plus out gnd
*.ipin minus
*.ipin plus
*.ipin VDD
*.ipin gnd
*.opin out
XM6 net3 net3 gnd GND sky130_fd_pr__nfet_01v8 L=1.5 W=0.564 nf=1 ad='int((1 + 1)/2) * 0.564 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.564 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.564 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.564 / 1 + 0.29)'
+ nrd='0.29 / 0.564 ' nrs='0.29 / 0.564 ' sa=0 sb=0 sd=0 mult=1 m=1
XM8 out Vdiff gnd GND sky130_fd_pr__nfet_01v8 L=0.5 W=12 nf=1 ad='int((1 + 1)/2) * 12 / 1 * 0.29' as='int((1 + 2)/2) * 12 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (12 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (12 / 1 + 0.29)' nrd='0.29 / 12 ' nrs='0.29 / 12 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 net3 minus net1 VDD sky130_fd_pr__pfet_01v8_lvt L=1.5 W=2.644 nf=2 ad='int((2 + 1)/2) * 2.644 / 2 * 0.29'
+ as='int((2 + 2)/2) * 2.644 / 2 * 0.29' pd='2*int((2 + 1)/2) * (2.644 / 2 + 0.29)' ps='2*int((2 + 2)/2) * (2.644 / 2 + 0.29)'
+ nrd='0.29 / 2.644 ' nrs='0.29 / 2.644 ' sa=0 sb=0 sd=0 mult=5 m=5
XM3 Vdiff net3 gnd GND sky130_fd_pr__nfet_01v8 L=1.5 W=0.564 nf=1 ad='int((1 + 1)/2) * 0.564 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.564 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.564 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.564 / 1 + 0.29)'
+ nrd='0.29 / 0.564 ' nrs='0.29 / 0.564 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net1 net2 VDD VDD sky130_fd_pr__pfet_01v8 L=0.75 W=0.515 nf=1 ad='int((1 + 1)/2) * 0.515 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.515 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.515 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.515 / 1 + 0.29)'
+ nrd='0.29 / 0.515 ' nrs='0.29 / 0.515 ' sa=0 sb=0 sd=0 mult=4 m=4
XM2 Vdiff plus net1 VDD sky130_fd_pr__pfet_01v8_lvt L=1.5 W=2.644 nf=2 ad='int((2 + 1)/2) * 2.644 / 2 * 0.29'
+ as='int((2 + 2)/2) * 2.644 / 2 * 0.29' pd='2*int((2 + 1)/2) * (2.644 / 2 + 0.29)' ps='2*int((2 + 2)/2) * (2.644 / 2 + 0.29)'
+ nrd='0.29 / 2.644 ' nrs='0.29 / 2.644 ' sa=0 sb=0 sd=0 mult=5 m=5
XR4 net4 Vdiff gnd sky130_fd_pr__res_xhigh_po_1p41 L=14.5 mult=1 m=1
XC3 out net4 sky130_fd_pr__cap_mim_m3_1 W=1 L=25 MF=20 m=20
XM7 net2 net2 VDD VDD sky130_fd_pr__pfet_01v8 L=0.75 W=0.515 nf=1 ad='int((1 + 1)/2) * 0.515 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.515 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.515 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.515 / 1 + 0.29)'
+ nrd='0.29 / 0.515 ' nrs='0.29 / 0.515 ' sa=0 sb=0 sd=0 mult=4 m=4
XM5 out net2 VDD VDD sky130_fd_pr__pfet_01v8 L=0.75 W=0.515 nf=1 ad='int((1 + 1)/2) * 0.515 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.515 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.515 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.515 / 1 + 0.29)'
+ nrd='0.29 / 0.515 ' nrs='0.29 / 0.515 ' sa=0 sb=0 sd=0 mult=4 m=4
XR8 net7 net2 gnd sky130_fd_pr__res_xhigh_po_1p41 L=11.75 mult=1 m=1
XR5 net6 net7 gnd sky130_fd_pr__res_xhigh_po_1p41 L=11.75 mult=1 m=1
XR6 net5 net6 gnd sky130_fd_pr__res_xhigh_po_1p41 L=11.75 mult=1 m=1
XR9 gnd net5 gnd sky130_fd_pr__res_xhigh_po_1p41 L=11.75 mult=1 m=1
.ends

.GLOBAL VDD
.GLOBAL GND
.end
