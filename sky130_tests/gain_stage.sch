** sch_path: sky130_tests/gain_stage.sch
* Copyright 2021 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
**.subckt gain_stage IN VSS VCC OUT START START_N EN_N
*.ipin IN
*.ipin VSS
*.ipin VCC
*.opin OUT
*.ipin START
*.ipin START_N
*.ipin EN_N
C5 OUT 0 4f m=1
XM6 OUT IN net1 VSS sky130_fd_pr__@modeln L=1 W=WN nf=1 ad='int((1 + 1)/2) * WN / 1 * 0.29' as='int((1 + 2)/2) * WN / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WN / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WN / 1 + 0.29)' nrd='0.29 / WN ' nrs='0.29 / WN '
+ sa=0 sb=0 sd=0 mult=1 m=1
v4 net1 VSS 0
.save i(v4)
XM7 OUT EN_N VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1 + 2)/2) * 0.5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 '
+ sa=0 sb=0 sd=0 mult=3 m=3
XM46 net6 EN_N VCC VCC sky130_fd_pr__pfet_01v8 L=0.15 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1 + 2)/2) * 5 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29 / 5 ' nrs='0.29 / 5 '
+ sa=0 sb=0 sd=0 mult=1 m=1
v17 net6 net2 0
.save i(v17)
XM5 OUT IN net2 VCC sky130_fd_pr__pfet_01v8_lvt L=1 W=WP nf=1 ad='int((1 + 1)/2) * WP / 1 * 0.29' as='int((1 + 2)/2) * WP / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WP / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WP / 1 + 0.29)' nrd='0.29 / WP ' nrs='0.29 / WP '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net4 ADJ net3 VCC sky130_fd_pr__pfet_01v8_lvt L=1 W=WP nf=1 ad='int((1 + 1)/2) * WP / 1 * 0.29' as='int((1 + 2)/2) * WP / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WP / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WP / 1 + 0.29)' nrd='0.29 / WP ' nrs='0.29 / WP '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 net4 ADJ net5 VSS sky130_fd_pr__@modeln L=1 W=WN nf=1 ad='int((1 + 1)/2) * WN / 1 * 0.29' as='int((1 + 2)/2) * WN / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WN / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WN / 1 + 0.29)' nrd='0.29 / WN ' nrs='0.29 / WN '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net5 VCC VSS VSS sky130_fd_pr__nfet_01v8 L=4 W=WN nf=1 ad='int((1 + 1)/2) * WN / 1 * 0.29' as='int((1 + 2)/2) * WN / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WN / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WN / 1 + 0.29)' nrd='0.29 / WN ' nrs='0.29 / WN '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 net3 EN_N VCC VCC sky130_fd_pr__pfet_01v8 L=4 W=WP nf=1 ad='int((1 + 1)/2) * WP / 1 * 0.29' as='int((1 + 2)/2) * WP / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (WP / 1 + 0.29)' ps='2*int((1 + 2)/2) * (WP / 1 + 0.29)' nrd='0.29 / WP ' nrs='0.29 / WP '
+ sa=0 sb=0 sd=0 mult=1 m=1
C1 IN 0 4f m=1
x6 ADJ OUT START START_N VCC VSS passgate_1 W_N=0.42 L_N=0.35 W_P=0.6 L_P=0.35 m=1
XC2 ADJ VSS sky130_fd_pr__cap_mim_m3_2 W=wcap L=wcap MF=2 m=2
v1 net4 OUT 0
.save i(v1)
**.ends
.end
