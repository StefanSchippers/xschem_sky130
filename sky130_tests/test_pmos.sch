** sch_path: sky130_tests/test_pmos.sch
* Copyright 2021 Stefan Frederik Schippers
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* https://www.apache.org/licenses/LICENSE-2.0
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
* AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA1H49AAAAQCWVhz0AAADAaeCQPQAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAOg1DUpmgJC9kGZU3H+gpL1Bn/1KZoCA
**.subckt test_pmos G1v8 D1v8 B
*.ipin G1v8
*.ipin D1v8
*.ipin B
Vd1 net1 D1v8 0
.save i(vd1)
Vd2 net2 D1v8 0
.save i(vd2)
E1 D5v0 0 D1v8 0 '5/1.8'
E2 D3v3 0 D1v8 0 '3.3/1.8'
E3 G5v0 0 G1v8 0 '5/1.8'
E4 G3v3 0 G1v8 0 '3.3/1.8'
E5 D10v5 0 D1v8 0 '10.5/1.8'
Vd3 net3 D1v8 0
.save i(vd3)
XM3 net3 G1v8 S B sky130_fd_pr__pfet_01v8_hvt W=1 L=0.15 ad='W * 0.29' pd='W + 2 * 0.29' as='W * 0.29'
+ ps='W + 2 * 0.29' nrd=0 nrs=0 sa=0 sb=0 sd=0 nf=1 mult=1
Vd4 net4 D10v5 0
.save i(vd4)
XM4 net4 G5v0 S B sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 net1 G1v8 S B sky130_fd_pr__pfet_01v8_lvt L=0.35 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 net2 G1v8 S B sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vd5 net5 D16v0 0
.save i(vd5)
XM5 net5 G5v0 S B sky130_fd_pr__pfet_g5v0d16v0 W=5.0 L=0.66 ad='int((nf+1)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)'
+ as='int((nf+2)/2) * W/nf * 0.29' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0
+ sb=0 sd=0 nf=1 mult=1 m=1
E6 D16v0 0 D1v8 0 '16.0/1.8'
E7 D20v0 0 D1v8 0 '20.0/1.8'
XM6 net6 G5v0 S B sky130_fd_pr__pfet_20v0 L=0.5 W=30 m=1
Vd6 net6 D20v0 0
.save i(vd6)
**** begin user architecture code

* this option enables mos model bin
* selection based on W/NF instead of W
.opton wnflag=1
.option savecurrents
vg G1v8 0 0
vs s 0 0
vd D1v8 0 0
vb b 0 0
.control
save all
dc vd 0 -1.8 -0.01 vg 0 -1.8 -0.2
write test_pmos.raw
plot all.vd1#branch vs D1v8
plot all.vd2#branch vs D1v8
plot all.vd3#branch vs D1v8
plot all.vd4#branch vs D10v5
plot all.vd5#branch vs D16v0
plot all.vd6#branch vs D20v0
set appendwrite
op
write test_pmos.raw
.endc


[
set sky130_corner(tt) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh) "
.param mc_mm_switch=0
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(tt_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(sf_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/sf.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/sf/specialized_cells.spice
"
set sky130_corner(ff_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ff.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ff/specialized_cells.spice
"
set sky130_corner(ss_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/ss.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/ss/specialized_cells.spice
"
set sky130_corner(fs_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/fs.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/r+c/res_typical__cap_typical__lin.spice
.include $::SKYWATER_MODELS/corners/fs/specialized_cells.spice
"
set sky130_corner(ll_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(hl_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low.spice
.include $::SKYWATER_MODELS/r+c/res_high__cap_low__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(lh_mm) "
.param mc_mm_switch=1
.param mc_pr_switch=0
.include $::SKYWATER_MODELS/corners/tt.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high.spice
.include $::SKYWATER_MODELS/r+c/res_low__cap_high__lin.spice
.include $::SKYWATER_MODELS/corners/tt/specialized_cells.spice
"
set sky130_corner(mc) "
.param mc_mm_switch=0
.param mc_pr_switch=1
.include $::SKYWATER_MODELS/parameters/critical.spice
.include $::SKYWATER_MODELS/parameters/montecarlo.spice
"
return {}
]$sky130_corner(tt)
**** end user architecture code
**.ends
.end
