** sch_path: sky130_tests/test_multisim.sch
**.subckt test_multisim
V4 VCC 0 pwl 0 0 1u 0 1.001u 1.8
R1 0 A 100K m=1
C2 A VCC 30p m=1
**** begin user architecture code
 [if [sim_is_ngspice] {return {

** ngspice
.control
  save all
  tran 1n 20u uic
  write test_multisim.raw
.endc

}}]
 [if [sim_is_xyce] {return {

** Xyce
.tran 1n 20u uic

}}]
**** end user architecture code
**.ends
.end
