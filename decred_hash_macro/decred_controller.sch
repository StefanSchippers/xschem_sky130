v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {This schematic is empty. 
It is very big, you must regenerate it if you 
need it. See readme.md file} 50 -130 0 0 0.4 0.4 {}
